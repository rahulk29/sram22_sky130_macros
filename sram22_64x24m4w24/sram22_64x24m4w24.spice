* sram22_64x24m4w24
* Schematic generated by Substrate

.subckt sram22_64x24m4w24
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]

X0
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ sram22_inner
.ends sram22_64x24m4w24

.subckt sram22_inner
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]

Xaddr_gate
+ vdd
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ wl_en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ vss
+ addr_gate
Xdecoder
+ vdd
+ vss
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl_b[0]
+ wl_b[1]
+ wl_b[2]
+ wl_b[3]
+ wl_b[4]
+ wl_b[5]
+ wl_b[6]
+ wl_b[7]
+ wl_b[8]
+ wl_b[9]
+ wl_b[10]
+ wl_b[11]
+ wl_b[12]
+ wl_b[13]
+ wl_b[14]
+ wl_b[15]
+ decoder
Xcolumn_decoder
+ vdd
+ vss
+ addr_in[0]
+ addr_in[1]
+ addr_in_b[0]
+ addr_in_b[1]
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ decoder_1
Xwmux_driver
+ vdd
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ write_driver_en
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmux_sel_b[0]
+ wmux_sel_b[1]
+ wmux_sel_b[2]
+ wmux_sel_b[3]
+ vss
+ wmux_driver
Xcontrol_logic
+ clk
+ we_in
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss
+ control_logic_replica_v2
Xaddr_we_dffs
+ vdd
+ vss
+ clk
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ we
+ addr_in[0]
+ addr_in[1]
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ we_in
+ addr_in_b[0]
+ addr_in_b[1]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ we_in_b
+ dff_array_7
Xbitcell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ sp_cell_array
Xreplica_bitcell_array
+ vdd
+ vss
+ rbl
+ rbr
+ wl_en0
+ replica_cell_array
Xcol_circuitry
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ pc_b
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ col_peripherals
Xreplica_precharge_0
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
Xreplica_precharge_1
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
.ends sram22_inner

.subckt addr_gate
+ vdd
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ vss

Xaddr_gate_0
+ vdd
+ addr[0]
+ en
+ addr_gated[0]
+ int1[0]
+ vss
+ and2
Xaddr_b_gate_0
+ vdd
+ addr_b[0]
+ en
+ addr_b_gated[0]
+ int2[0]
+ vss
+ and2
Xaddr_gate_1
+ vdd
+ addr[1]
+ en
+ addr_gated[1]
+ int1[1]
+ vss
+ and2
Xaddr_b_gate_1
+ vdd
+ addr_b[1]
+ en
+ addr_b_gated[1]
+ int2[1]
+ vss
+ and2
Xaddr_gate_2
+ vdd
+ addr[2]
+ en
+ addr_gated[2]
+ int1[2]
+ vss
+ and2
Xaddr_b_gate_2
+ vdd
+ addr_b[2]
+ en
+ addr_b_gated[2]
+ int2[2]
+ vss
+ and2
Xaddr_gate_3
+ vdd
+ addr[3]
+ en
+ addr_gated[3]
+ int1[3]
+ vss
+ and2
Xaddr_b_gate_3
+ vdd
+ addr_b[3]
+ en
+ addr_b_gated[3]
+ int2[3]
+ vss
+ and2
.ends addr_gate

.subckt decoder
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ decoder_stage
X0_1
+ vdd
+ vss
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ unused_2[0]
+ unused_2[1]
+ unused_2[2]
+ unused_2[3]
+ addr_b[3]
+ addr[3]
+ addr_b[2]
+ addr[2]
+ decoder_stage_1
X0_2
+ vdd
+ vss
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ unused_3[0]
+ unused_3[1]
+ unused_3[2]
+ unused_3[3]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_1
.ends decoder

.subckt decoder_1
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr_b[0]
+ addr_b[1]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_2
.ends decoder_1

.subckt wmux_driver
+ vdd
+ in[0]
+ in[1]
+ in[2]
+ in[3]
+ en
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ vss

Xgate_0
+ vdd
+ in[0]
+ en
+ decode[0]
+ decode_b[0]
+ vss
+ and2_1
Xgate_1
+ vdd
+ in[1]
+ en
+ decode[1]
+ decode_b[1]
+ vss
+ and2_1
Xgate_2
+ vdd
+ in[2]
+ en
+ decode[2]
+ decode_b[2]
+ vss
+ and2_1
Xgate_3
+ vdd
+ in[3]
+ en
+ decode[3]
+ decode_b[3]
+ vss
+ and2_1
.ends wmux_driver

.subckt control_logic_replica_v2
+ clk
+ we
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss

Xinv_clk
+ clk
+ vss
+ vss
+ vdd
+ vdd
+ clk_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_clk_b
+ clk_b
+ vss
+ vss
+ vdd
+ vdd
+ clk_buf
+ sky130_fd_sc_hd__inv_2_wrapper
Xclk_pulse
+ clk_buf
+ clkp
+ vdd
+ vss
+ edge_detector
Xdecoder_replica
+ clkp
+ wl_en_set
+ vdd
+ vss
+ inv_chain_4
Xinv_we
+ we
+ vss
+ vss
+ vdd
+ vdd
+ we_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_rbl
+ rbl
+ vss
+ vss
+ vdd
+ vdd
+ rbl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xpc_read_set_buf
+ rbl_b
+ pc_read_set
+ vdd
+ vss
+ inv_chain_48
Xand_sense_en
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sense_en_set0
+ sky130_fd_sc_hd__and2_2_wrapper
Xsense_en_delay
+ sense_en_set0
+ sense_en_set
+ vdd
+ vss
+ inv_chain_48
Xwl_ctl
+ wl_en_set
+ wl_en_rst
+ wl_en0
+ wl_en0_b
+ vdd
+ vss
+ sr_latch
Xsae_ctl
+ sense_en_set
+ clkp
+ sense_en0
+ sense_en_b
+ vdd
+ vss
+ sr_latch
Xpc_ctl
+ pc_set
+ clkp
+ pc
+ pc_b0
+ vdd
+ vss
+ sr_latch
Xwr_drv_ctl
+ wr_drv_set
+ wl_en_write_rst
+ write_driver_en0
+ write_driver_en_b
+ vdd
+ vss
+ sr_latch
Xmux_wl_en_rst
+ rbl_b
+ wl_en_write_rst
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wl_en_rst
+ sky130_fd_sc_hd__mux2_2_wrapper
Xmux_pc_set
+ pc_read_set
+ pc_write_set
+ we
+ vss
+ vss
+ vdd
+ vdd
+ pc_set
+ sky130_fd_sc_hd__mux2_2_wrapper
Xsae_set
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sae_set
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set
+ clkp
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wr_drv_set_undelayed
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set_decoder_delay_replica
+ wr_drv_set_undelayed
+ wr_drv_set
+ vdd
+ vss
+ inv_chain_8
Xinv_dummy_bl
+ dummy_bl
+ vss
+ vss
+ vdd
+ vdd
+ dummy_bl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xwl_en_write_rst_buf
+ dummy_bl_b
+ wl_en_write_rst
+ vdd
+ vss
+ inv_chain_4
Xpc_write_set_buf
+ wl_en_write_rst
+ pc_write_set
+ vdd
+ vss
+ inv_chain_16
Xwl_en_buf
+ wl_en0
+ vss
+ vss
+ vdd
+ vdd
+ wl_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf
+ sense_en0
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf2
+ sense_en0
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf2
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwr_drv_buf
+ write_driver_en0
+ vss
+ vss
+ vdd
+ vdd
+ write_driver_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwbl_pulldown_en
+ wl_en
+ write_driver_en
+ vss
+ vss
+ vdd
+ vdd
+ wbl_pulldown_en
+ sky130_fd_sc_hd__and2_2_wrapper
Xdummy_bl_pulldown
+ dummy_bl
+ wbl_pulldown_en
+ vss
+ vss
+ mos_w420_l150_m1_nf1_id0
.ends control_logic_replica_v2

.subckt dff_array_7
+ vdd
+ vss
+ clk
+ d[0]
+ d[1]
+ d[2]
+ d[3]
+ d[4]
+ d[5]
+ d[6]
+ q[0]
+ q[1]
+ q[2]
+ q[3]
+ q[4]
+ q[5]
+ q[6]
+ qn[0]
+ qn[1]
+ qn[2]
+ qn[3]
+ qn[4]
+ qn[5]
+ qn[6]

Xdff_0
+ vdd
+ vss
+ clk
+ d[0]
+ q[0]
+ qn[0]
+ openram_dff_wrapper
Xdff_1
+ vdd
+ vss
+ clk
+ d[1]
+ q[1]
+ qn[1]
+ openram_dff_wrapper
Xdff_2
+ vdd
+ vss
+ clk
+ d[2]
+ q[2]
+ qn[2]
+ openram_dff_wrapper
Xdff_3
+ vdd
+ vss
+ clk
+ d[3]
+ q[3]
+ qn[3]
+ openram_dff_wrapper
Xdff_4
+ vdd
+ vss
+ clk
+ d[4]
+ q[4]
+ qn[4]
+ openram_dff_wrapper
Xdff_5
+ vdd
+ vss
+ clk
+ d[5]
+ q[5]
+ qn[5]
+ openram_dff_wrapper
Xdff_6
+ vdd
+ vss
+ clk
+ d[6]
+ q[6]
+ qn[6]
+ openram_dff_wrapper
.ends dff_array_7

.subckt sp_cell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]

Xcell_0_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_0
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_0
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_1
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_1
+ vdd
+ vdd
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_2
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_2
+ vdd
+ vdd
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_3
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_3
+ vdd
+ vdd
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_4
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_4
+ vdd
+ vdd
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_5
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_5
+ vdd
+ vdd
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_6
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_6
+ vdd
+ vdd
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_7
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_7
+ vdd
+ vdd
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_8
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_8
+ vdd
+ vdd
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_9
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_9
+ vdd
+ vdd
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_10
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_10
+ vdd
+ vdd
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_11
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_11
+ vdd
+ vdd
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_12
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_12
+ vdd
+ vdd
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_13
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_13
+ vdd
+ vdd
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_14
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_14
+ vdd
+ vdd
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_15
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_15
+ vdd
+ vdd
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_16
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_16
+ vdd
+ vdd
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_17
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_17
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcolend_top_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_97
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_97
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_97
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_97
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_97
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
.ends sp_cell_array

.subckt replica_cell_array
+ vdd
+ vss
+ rbl
+ rbr
+ rwl

Xcell_0_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_0_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_1_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_1_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcolend_0_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_0_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
.ends replica_cell_array

.subckt col_peripherals
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]

Xwmask_dffs
+ vdd
+ vss
+ clk
+ wmask
+ wmask_in
+ wmask_in_b
+ dff_array_1
Xcol_group_0
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[0]
+ dout[0]
+ sense_en
+ column
Xcol_group_1
+ clk
+ vdd
+ vss
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[1]
+ dout[1]
+ sense_en
+ column
Xcol_group_2
+ clk
+ vdd
+ vss
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[2]
+ dout[2]
+ sense_en
+ column
Xcol_group_3
+ clk
+ vdd
+ vss
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[3]
+ dout[3]
+ sense_en
+ column
Xcol_group_4
+ clk
+ vdd
+ vss
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[4]
+ dout[4]
+ sense_en
+ column
Xcol_group_5
+ clk
+ vdd
+ vss
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[5]
+ dout[5]
+ sense_en
+ column
Xcol_group_6
+ clk
+ vdd
+ vss
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[6]
+ dout[6]
+ sense_en
+ column
Xcol_group_7
+ clk
+ vdd
+ vss
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[7]
+ dout[7]
+ sense_en
+ column
Xcol_group_8
+ clk
+ vdd
+ vss
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[8]
+ dout[8]
+ sense_en
+ column
Xcol_group_9
+ clk
+ vdd
+ vss
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[9]
+ dout[9]
+ sense_en
+ column
Xcol_group_10
+ clk
+ vdd
+ vss
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[10]
+ dout[10]
+ sense_en
+ column
Xcol_group_11
+ clk
+ vdd
+ vss
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[11]
+ dout[11]
+ sense_en
+ column
Xcol_group_12
+ clk
+ vdd
+ vss
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[12]
+ dout[12]
+ sense_en
+ column
Xcol_group_13
+ clk
+ vdd
+ vss
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[13]
+ dout[13]
+ sense_en
+ column
Xcol_group_14
+ clk
+ vdd
+ vss
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[14]
+ dout[14]
+ sense_en
+ column
Xcol_group_15
+ clk
+ vdd
+ vss
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[15]
+ dout[15]
+ sense_en
+ column
Xcol_group_16
+ clk
+ vdd
+ vss
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[16]
+ dout[16]
+ sense_en
+ column
Xcol_group_17
+ clk
+ vdd
+ vss
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[17]
+ dout[17]
+ sense_en
+ column
Xcol_group_18
+ clk
+ vdd
+ vss
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[18]
+ dout[18]
+ sense_en
+ column
Xcol_group_19
+ clk
+ vdd
+ vss
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[19]
+ dout[19]
+ sense_en
+ column
Xcol_group_20
+ clk
+ vdd
+ vss
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[20]
+ dout[20]
+ sense_en
+ column
Xcol_group_21
+ clk
+ vdd
+ vss
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[21]
+ dout[21]
+ sense_en
+ column
Xcol_group_22
+ clk
+ vdd
+ vss
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[22]
+ dout[22]
+ sense_en
+ column
Xcol_group_23
+ clk
+ vdd
+ vss
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[23]
+ dout[23]
+ sense_en
+ column
Xdummy_precharge
+ vdd
+ dummy_bl
+ dummy_br
+ pc_b
+ precharge
Xdummy_precharge_noconn
+ vdd
+ dummy_bl_noconn
+ dummy_br_noconn
+ pc_b
+ precharge
.ends col_peripherals

.subckt precharge
+ vdd
+ bl
+ br
+ en_b

Xbl_pull_up
+ bl
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xbr_pull_up
+ br
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xequalizer
+ bl
+ en_b
+ br
+ vdd
+ mos_w1200_l150_m1_nf1_id1
.ends precharge

.subckt and2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2

.subckt decoder_stage
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ a[0]
+ a[1]
+ a[2]
+ a[3]
+ b[0]
+ b[1]
+ b[2]
+ b[3]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_2
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_2
X0_2
+ vdd
+ a[0]
+ b[2]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_2
X0_3
+ vdd
+ a[0]
+ b[3]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_2
X0_4
+ vdd
+ a[1]
+ b[0]
+ decode[4]
+ decode_b[4]
+ vss
+ and2_2
X0_5
+ vdd
+ a[1]
+ b[1]
+ decode[5]
+ decode_b[5]
+ vss
+ and2_2
X0_6
+ vdd
+ a[1]
+ b[2]
+ decode[6]
+ decode_b[6]
+ vss
+ and2_2
X0_7
+ vdd
+ a[1]
+ b[3]
+ decode[7]
+ decode_b[7]
+ vss
+ and2_2
X0_8
+ vdd
+ a[2]
+ b[0]
+ decode[8]
+ decode_b[8]
+ vss
+ and2_2
X0_9
+ vdd
+ a[2]
+ b[1]
+ decode[9]
+ decode_b[9]
+ vss
+ and2_2
X0_10
+ vdd
+ a[2]
+ b[2]
+ decode[10]
+ decode_b[10]
+ vss
+ and2_2
X0_11
+ vdd
+ a[2]
+ b[3]
+ decode[11]
+ decode_b[11]
+ vss
+ and2_2
X0_12
+ vdd
+ a[3]
+ b[0]
+ decode[12]
+ decode_b[12]
+ vss
+ and2_2
X0_13
+ vdd
+ a[3]
+ b[1]
+ decode[13]
+ decode_b[13]
+ vss
+ and2_2
X0_14
+ vdd
+ a[3]
+ b[2]
+ decode[14]
+ decode_b[14]
+ vss
+ and2_2
X0_15
+ vdd
+ a[3]
+ b[3]
+ decode[15]
+ decode_b[15]
+ vss
+ and2_2
.ends decoder_stage

.subckt decoder_stage_1
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ a[0]
+ a[1]
+ b[0]
+ b[1]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_3
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_3
X0_2
+ vdd
+ a[1]
+ b[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_3
X0_3
+ vdd
+ a[1]
+ b[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_3
.ends decoder_stage_1

.subckt decoder_stage_2
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ a[0]
+ a[1]
+ b[0]
+ b[1]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_4
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_4
X0_2
+ vdd
+ a[1]
+ b[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_4
X0_3
+ vdd
+ a[1]
+ b[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_4
.ends decoder_stage_2

.subckt and2_1
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_1

.subckt sky130_fd_sc_hd__inv_2_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__inv_2
.ends sky130_fd_sc_hd__inv_2_wrapper

.subckt edge_detector
+ din
+ dout
+ vdd
+ vss

Xdelay_chain
+ din
+ delayed
+ vdd
+ vss
+ inv_chain_9
Xand
+ din
+ delayed
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__and2_4_wrapper
.ends edge_detector

.subckt inv_chain_4
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_4

.subckt inv_chain_48
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ x[15]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv16
+ x[15]
+ vss
+ vss
+ vdd
+ vdd
+ x[16]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv17
+ x[16]
+ vss
+ vss
+ vdd
+ vdd
+ x[17]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv18
+ x[17]
+ vss
+ vss
+ vdd
+ vdd
+ x[18]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv19
+ x[18]
+ vss
+ vss
+ vdd
+ vdd
+ x[19]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv20
+ x[19]
+ vss
+ vss
+ vdd
+ vdd
+ x[20]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv21
+ x[20]
+ vss
+ vss
+ vdd
+ vdd
+ x[21]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv22
+ x[21]
+ vss
+ vss
+ vdd
+ vdd
+ x[22]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv23
+ x[22]
+ vss
+ vss
+ vdd
+ vdd
+ x[23]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv24
+ x[23]
+ vss
+ vss
+ vdd
+ vdd
+ x[24]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv25
+ x[24]
+ vss
+ vss
+ vdd
+ vdd
+ x[25]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv26
+ x[25]
+ vss
+ vss
+ vdd
+ vdd
+ x[26]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv27
+ x[26]
+ vss
+ vss
+ vdd
+ vdd
+ x[27]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv28
+ x[27]
+ vss
+ vss
+ vdd
+ vdd
+ x[28]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv29
+ x[28]
+ vss
+ vss
+ vdd
+ vdd
+ x[29]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv30
+ x[29]
+ vss
+ vss
+ vdd
+ vdd
+ x[30]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv31
+ x[30]
+ vss
+ vss
+ vdd
+ vdd
+ x[31]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv32
+ x[31]
+ vss
+ vss
+ vdd
+ vdd
+ x[32]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv33
+ x[32]
+ vss
+ vss
+ vdd
+ vdd
+ x[33]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv34
+ x[33]
+ vss
+ vss
+ vdd
+ vdd
+ x[34]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv35
+ x[34]
+ vss
+ vss
+ vdd
+ vdd
+ x[35]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv36
+ x[35]
+ vss
+ vss
+ vdd
+ vdd
+ x[36]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv37
+ x[36]
+ vss
+ vss
+ vdd
+ vdd
+ x[37]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv38
+ x[37]
+ vss
+ vss
+ vdd
+ vdd
+ x[38]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv39
+ x[38]
+ vss
+ vss
+ vdd
+ vdd
+ x[39]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv40
+ x[39]
+ vss
+ vss
+ vdd
+ vdd
+ x[40]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv41
+ x[40]
+ vss
+ vss
+ vdd
+ vdd
+ x[41]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv42
+ x[41]
+ vss
+ vss
+ vdd
+ vdd
+ x[42]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv43
+ x[42]
+ vss
+ vss
+ vdd
+ vdd
+ x[43]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv44
+ x[43]
+ vss
+ vss
+ vdd
+ vdd
+ x[44]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv45
+ x[44]
+ vss
+ vss
+ vdd
+ vdd
+ x[45]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv46
+ x[45]
+ vss
+ vss
+ vdd
+ vdd
+ x[46]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv47
+ x[46]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_48

.subckt sky130_fd_sc_hd__and2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_2
.ends sky130_fd_sc_hd__and2_2_wrapper

.subckt sr_latch
+ s
+ r
+ q
+ qb
+ vdd
+ vss

Xnor_set
+ s
+ q
+ vss
+ vss
+ vdd
+ vdd
+ qb
+ sky130_fd_sc_hd__nor2_2_wrapper
Xnor_reset
+ r
+ qb
+ vss
+ vss
+ vdd
+ vdd
+ q
+ sky130_fd_sc_hd__nor2_2_wrapper
.ends sr_latch

.subckt sky130_fd_sc_hd__mux2_2_wrapper
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__mux2_2
.ends sky130_fd_sc_hd__mux2_2_wrapper

.subckt inv_chain_8
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_8

.subckt inv_chain_16
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_16

.subckt sky130_fd_sc_hd__bufbuf_16_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__bufbuf_16
.ends sky130_fd_sc_hd__bufbuf_16_wrapper

.subckt mos_w420_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=0.420 l=0.150 nf=1 mult=1
.ends mos_w420_l150_m1_nf1_id0

.subckt openram_dff_wrapper
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N

X0
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N
+ openram_dff
.ends openram_dff_wrapper

.subckt sram_sp_cell_wrapper
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB

X0
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB
+ sram_sp_cell
.ends sram_sp_cell_wrapper

.subckt sram_sp_colend_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_colend
.ends sram_sp_colend_wrapper

.subckt sram_sp_hstrap_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_hstrap
.ends sram_sp_hstrap_wrapper

.subckt sram_sp_cell_replica_wrapper
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL

X0
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL
+ sram_sp_cell_replica
.ends sram_sp_cell_replica_wrapper

.subckt dff_array_1
+ vdd
+ vss
+ clk
+ d
+ q
+ qn

Xdff_0
+ vdd
+ vss
+ clk
+ d
+ q
+ qn
+ openram_dff_wrapper
.ends dff_array_1

.subckt column
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask
+ din
+ dout
+ sense_en

Xprecharge_0
+ vdd
+ bl[0]
+ br[0]
+ pc_b
+ precharge
Xread_mux_0
+ sel_b[0]
+ bl[0]
+ br[0]
+ bl_out
+ br_out
+ vdd
+ read_mux
Xwrite_mux_0
+ we[0]
+ wmask
+ q
+ q_b
+ bl[0]
+ br[0]
+ vss
+ write_mux
Xprecharge_1
+ vdd
+ bl[1]
+ br[1]
+ pc_b
+ precharge
Xread_mux_1
+ sel_b[1]
+ bl[1]
+ br[1]
+ bl_out
+ br_out
+ vdd
+ read_mux_1
Xwrite_mux_1
+ we[1]
+ wmask
+ q
+ q_b
+ bl[1]
+ br[1]
+ vss
+ write_mux_1
Xprecharge_2
+ vdd
+ bl[2]
+ br[2]
+ pc_b
+ precharge
Xread_mux_2
+ sel_b[2]
+ bl[2]
+ br[2]
+ bl_out
+ br_out
+ vdd
+ read_mux_2
Xwrite_mux_2
+ we[2]
+ wmask
+ q
+ q_b
+ bl[2]
+ br[2]
+ vss
+ write_mux_2
Xprecharge_3
+ vdd
+ bl[3]
+ br[3]
+ pc_b
+ precharge
Xread_mux_3
+ sel_b[3]
+ bl[3]
+ br[3]
+ bl_out
+ br_out
+ vdd
+ read_mux_3
Xwrite_mux_3
+ we[3]
+ wmask
+ q
+ q_b
+ bl[3]
+ br[3]
+ vss
+ write_mux_3
Xsense_amp
+ sense_en
+ br_out
+ bl_out
+ sa_outn
+ sa_outp
+ vdd
+ vss
+ sramgen_sp_sense_amp_wrapper
Xbuf
+ vdd
+ vss
+ sa_outp
+ sa_outn
+ dout
+ diff_buf_outn
+ diff_buf
Xdff
+ vdd
+ vss
+ clk
+ din
+ q
+ q_b
+ openram_dff_wrapper
.ends column

.subckt mos_w2000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=2.000 l=0.150 nf=1 mult=1
.ends mos_w2000_l150_m1_nf1_id1

.subckt mos_w1200_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id1

.subckt nand2
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w8000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w8000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
.ends nand2

.subckt inv
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w13600_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1200_l150_m1_nf1_id0
.ends inv

.subckt and2_2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2_2

.subckt and2_3
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_2
.ends and2_3

.subckt and2_4
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_4

.subckt nand2_1
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends nand2_1

.subckt inv_1
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w2000_l150_m1_nf1_id0
.ends inv_1

.subckt inv_chain_9
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_9

.subckt sky130_fd_sc_hd__and2_4_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_4
.ends sky130_fd_sc_hd__and2_4_wrapper

.subckt sky130_fd_sc_hd__nor2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__nor2_2
.ends sky130_fd_sc_hd__nor2_2_wrapper

.subckt read_mux
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux

.subckt write_mux
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux

.subckt read_mux_1
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_1

.subckt write_mux_1
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_1

.subckt read_mux_2
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_2

.subckt write_mux_2
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_2

.subckt read_mux_3
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_3

.subckt write_mux_3
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_3

.subckt sramgen_sp_sense_amp_wrapper
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS

X0
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS
+ sramgen_sp_sense_amp
.ends sramgen_sp_sense_amp_wrapper

.subckt diff_buf
+ vdd
+ vss
+ din1
+ din2
+ dout1
+ dout2

Xbuf_1
+ vdd
+ vss
+ din1
+ dout1
+ buf
Xbuf_2
+ vdd
+ vss
+ din2
+ dout2
+ buf
.ends diff_buf

.subckt mos_w8000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=8.000 l=0.150 nf=1 mult=1
.ends mos_w8000_l150_m1_nf1_id0

.subckt mos_w13600_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=13.600 l=0.150 nf=1 mult=1
.ends mos_w13600_l150_m1_nf1_id1

.subckt mos_w1200_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id0

.subckt nand2_2
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
.ends nand2_2

.subckt inv_2
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w6800_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w600_l150_m1_nf1_id0
.ends inv_2

.subckt mos_w4000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=4.000 l=0.150 nf=1 mult=1
.ends mos_w4000_l150_m1_nf1_id0

.subckt mos_w4000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=4.000 l=0.150 nf=1 mult=1
.ends mos_w4000_l150_m1_nf1_id1

.subckt mos_w2000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=2.000 l=0.150 nf=1 mult=1
.ends mos_w2000_l150_m1_nf1_id0

.subckt mos_w3000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=3.000 l=0.150 nf=1 mult=1
.ends mos_w3000_l150_m1_nf1_id1

.subckt mos_w2400_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=2.400 l=0.150 nf=1 mult=1
.ends mos_w2400_l150_m1_nf1_id0

.subckt buf
+ vdd
+ vss
+ din
+ dout

Xinv_1
+ vdd
+ vss
+ din
+ x
+ inv_3
Xinv_2
+ vdd
+ vss
+ x
+ dout
+ inv_3
.ends buf

.subckt mos_w1000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.000 l=0.150 nf=1 mult=1
.ends mos_w1000_l150_m1_nf1_id1

.subckt mos_w6800_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=6.800 l=0.150 nf=1 mult=1
.ends mos_w6800_l150_m1_nf1_id1

.subckt mos_w600_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=0.600 l=0.150 nf=1 mult=1
.ends mos_w600_l150_m1_nf1_id0

.subckt inv_3
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1200_l150_m1_nf1_id0
.ends inv_3

.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/sram_sp_hstrap.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_4.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/bufbuf/sky130_fd_sc_hd__bufbuf_16.spice"
.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/openram_dff.spice"
.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/sramgen_sp_sense_amp.spice"
.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/sram_sp_cell.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_2.spice"
.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/sram_sp_cell_replica.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/mux2/sky130_fd_sc_hd__mux2_2.spice"
.include "/bwrcq/C/rahulkumar/personal/sram222/tech/sky130/spice/sram_sp_colend.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice"
