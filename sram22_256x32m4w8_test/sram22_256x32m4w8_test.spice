* sram22_256x32m4w8_test
* Schematic generated by Substrate

.subckt sram22_256x32m4w8_test
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ sae_int
+ sae_muxed

X0
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ sae_int
+ sae_muxed
+ sram22_inner
.ends sram22_256x32m4w8_test

.subckt sram22_inner
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ sae_int
+ sae_muxed

Xaddr_gate
+ vdd
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ addr_in[6]
+ addr_in[7]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ addr_in_b[6]
+ addr_in_b[7]
+ wl_en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ vss
+ addr_gate
Xdecoder
+ vdd
+ vss
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]
+ wl_b[0]
+ wl_b[1]
+ wl_b[2]
+ wl_b[3]
+ wl_b[4]
+ wl_b[5]
+ wl_b[6]
+ wl_b[7]
+ wl_b[8]
+ wl_b[9]
+ wl_b[10]
+ wl_b[11]
+ wl_b[12]
+ wl_b[13]
+ wl_b[14]
+ wl_b[15]
+ wl_b[16]
+ wl_b[17]
+ wl_b[18]
+ wl_b[19]
+ wl_b[20]
+ wl_b[21]
+ wl_b[22]
+ wl_b[23]
+ wl_b[24]
+ wl_b[25]
+ wl_b[26]
+ wl_b[27]
+ wl_b[28]
+ wl_b[29]
+ wl_b[30]
+ wl_b[31]
+ wl_b[32]
+ wl_b[33]
+ wl_b[34]
+ wl_b[35]
+ wl_b[36]
+ wl_b[37]
+ wl_b[38]
+ wl_b[39]
+ wl_b[40]
+ wl_b[41]
+ wl_b[42]
+ wl_b[43]
+ wl_b[44]
+ wl_b[45]
+ wl_b[46]
+ wl_b[47]
+ wl_b[48]
+ wl_b[49]
+ wl_b[50]
+ wl_b[51]
+ wl_b[52]
+ wl_b[53]
+ wl_b[54]
+ wl_b[55]
+ wl_b[56]
+ wl_b[57]
+ wl_b[58]
+ wl_b[59]
+ wl_b[60]
+ wl_b[61]
+ wl_b[62]
+ wl_b[63]
+ decoder
Xcolumn_decoder
+ vdd
+ vss
+ addr_in[0]
+ addr_in[1]
+ addr_in_b[0]
+ addr_in_b[1]
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ decoder_1
Xwmux_driver
+ vdd
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ write_driver_en
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmux_sel_b[0]
+ wmux_sel_b[1]
+ wmux_sel_b[2]
+ wmux_sel_b[3]
+ vss
+ wmux_driver
Xcontrol_logic
+ clk
+ we_in
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss
+ sae_int
+ sae_muxed
+ control_logic_replica_v2
Xaddr_we_dffs
+ vdd
+ vss
+ clk
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ we
+ addr_in[0]
+ addr_in[1]
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ addr_in[6]
+ addr_in[7]
+ we_in
+ addr_in_b[0]
+ addr_in_b[1]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ addr_in_b[6]
+ addr_in_b[7]
+ we_in_b
+ dff_array_9
Xbitcell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]
+ sp_cell_array
Xreplica_bitcell_array
+ vdd
+ vss
+ rbl
+ rbr
+ wl_en0
+ replica_cell_array
Xcol_circuitry
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ col_peripherals
Xreplica_precharge_0
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
Xreplica_precharge_1
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
.ends sram22_inner

.subckt addr_gate
+ vdd
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ addr_b[4]
+ addr_b[5]
+ en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ vss

Xaddr_gate_0
+ vdd
+ addr[0]
+ en
+ addr_gated[0]
+ int1[0]
+ vss
+ and2
Xaddr_b_gate_0
+ vdd
+ addr_b[0]
+ en
+ addr_b_gated[0]
+ int2[0]
+ vss
+ and2
Xaddr_gate_1
+ vdd
+ addr[1]
+ en
+ addr_gated[1]
+ int1[1]
+ vss
+ and2
Xaddr_b_gate_1
+ vdd
+ addr_b[1]
+ en
+ addr_b_gated[1]
+ int2[1]
+ vss
+ and2
Xaddr_gate_2
+ vdd
+ addr[2]
+ en
+ addr_gated[2]
+ int1[2]
+ vss
+ and2
Xaddr_b_gate_2
+ vdd
+ addr_b[2]
+ en
+ addr_b_gated[2]
+ int2[2]
+ vss
+ and2
Xaddr_gate_3
+ vdd
+ addr[3]
+ en
+ addr_gated[3]
+ int1[3]
+ vss
+ and2
Xaddr_b_gate_3
+ vdd
+ addr_b[3]
+ en
+ addr_b_gated[3]
+ int2[3]
+ vss
+ and2
Xaddr_gate_4
+ vdd
+ addr[4]
+ en
+ addr_gated[4]
+ int1[4]
+ vss
+ and2
Xaddr_b_gate_4
+ vdd
+ addr_b[4]
+ en
+ addr_b_gated[4]
+ int2[4]
+ vss
+ and2
Xaddr_gate_5
+ vdd
+ addr[5]
+ en
+ addr_gated[5]
+ int1[5]
+ vss
+ and2
Xaddr_b_gate_5
+ vdd
+ addr_b[5]
+ en
+ addr_b_gated[5]
+ int2[5]
+ vss
+ and2
.ends addr_gate

.subckt decoder
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ addr_b[4]
+ addr_b[5]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ a_1[4]
+ a_1[5]
+ a_1[6]
+ a_1[7]
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ b_1[4]
+ b_1[5]
+ b_1[6]
+ b_1[7]
+ decoder_stage
X0_1
+ vdd
+ vss
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ a_1[4]
+ a_1[5]
+ a_1[6]
+ a_1[7]
+ unused_2[0]
+ unused_2[1]
+ unused_2[2]
+ unused_2[3]
+ unused_2[4]
+ unused_2[5]
+ unused_2[6]
+ unused_2[7]
+ addr_b[5]
+ addr[5]
+ addr_b[4]
+ addr[4]
+ addr_b[3]
+ addr[3]
+ decoder_stage_1
X0_2
+ vdd
+ vss
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ b_1[4]
+ b_1[5]
+ b_1[6]
+ b_1[7]
+ unused_3[0]
+ unused_3[1]
+ unused_3[2]
+ unused_3[3]
+ unused_3[4]
+ unused_3[5]
+ unused_3[6]
+ unused_3[7]
+ addr_b[2]
+ addr[2]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_1
.ends decoder

.subckt decoder_1
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr_b[0]
+ addr_b[1]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_2
.ends decoder_1

.subckt wmux_driver
+ vdd
+ in[0]
+ in[1]
+ in[2]
+ in[3]
+ en
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ vss

Xgate_0
+ vdd
+ in[0]
+ en
+ decode[0]
+ decode_b[0]
+ vss
+ and2_1
Xgate_1
+ vdd
+ in[1]
+ en
+ decode[1]
+ decode_b[1]
+ vss
+ and2_1
Xgate_2
+ vdd
+ in[2]
+ en
+ decode[2]
+ decode_b[2]
+ vss
+ and2_1
Xgate_3
+ vdd
+ in[3]
+ en
+ decode[3]
+ decode_b[3]
+ vss
+ and2_1
.ends wmux_driver

.subckt control_logic_replica_v2
+ clk
+ we
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss
+ sae_int
+ sae_muxed

Xinv_clk
+ clk
+ vss
+ vss
+ vdd
+ vdd
+ clk_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_clk_b
+ clk_b
+ vss
+ vss
+ vdd
+ vdd
+ clk_buf
+ sky130_fd_sc_hd__inv_2_wrapper
Xclk_pulse
+ clk_buf
+ clkp
+ vdd
+ vss
+ edge_detector
Xdecoder_replica
+ clkp
+ wl_en_set
+ vdd
+ vss
+ inv_chain_8
Xinv_we
+ we
+ vss
+ vss
+ vdd
+ vdd
+ we_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_rbl
+ rbl
+ vss
+ vss
+ vdd
+ vdd
+ rbl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xpc_read_set_buf
+ rbl_b
+ pc_read_set
+ vdd
+ vss
+ inv_chain_8
Xand_sense_en
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sense_en_set0
+ sky130_fd_sc_hd__and2_2_wrapper
Xsense_en_delay
+ sense_en_set0
+ sense_en_set
+ vdd
+ vss
+ inv_chain_2
Xwl_ctl
+ wl_en_set
+ wl_en_rst
+ wl_en0
+ wl_en0_b
+ vdd
+ vss
+ sr_latch
Xsae_ctl
+ sense_en_set
+ clkp
+ sae_int
+ sense_en_b
+ vdd
+ vss
+ sr_latch
Xpc_ctl
+ pc_set
+ clkp
+ pc
+ pc_b0
+ vdd
+ vss
+ sr_latch
Xwr_drv_ctl
+ wr_drv_set
+ wl_en_write_rst
+ write_driver_en0
+ write_driver_en_b
+ vdd
+ vss
+ sr_latch
Xmux_wl_en_rst
+ rbl_b
+ wl_en_write_rst
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wl_en_rst
+ sky130_fd_sc_hd__mux2_2_wrapper
Xmux_pc_set
+ pc_read_set
+ pc_write_set
+ we
+ vss
+ vss
+ vdd
+ vdd
+ pc_set
+ sky130_fd_sc_hd__mux2_2_wrapper
Xsae_set
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sae_set
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set
+ clkp
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wr_drv_set_undelayed
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set_decoder_delay_replica
+ wr_drv_set_undelayed
+ wr_drv_set
+ vdd
+ vss
+ inv_chain_24
Xinv_dummy_bl
+ dummy_bl
+ vss
+ vss
+ vdd
+ vdd
+ dummy_bl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xwl_en_write_rst_buf
+ dummy_bl_b
+ wl_en_write_rst
+ vdd
+ vss
+ inv_chain_4
Xpc_write_set_buf
+ wl_en_write_rst
+ pc_write_set
+ vdd
+ vss
+ inv_chain_4
Xwl_en_buf
+ wl_en0
+ vss
+ vss
+ vdd
+ vdd
+ wl_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf
+ sae_muxed
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf2
+ sae_muxed
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf2
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwr_drv_buf
+ write_driver_en0
+ vss
+ vss
+ vdd
+ vdd
+ write_driver_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwbl_pulldown_en
+ wl_en
+ write_driver_en
+ vss
+ vss
+ vdd
+ vdd
+ wbl_pulldown_en
+ sky130_fd_sc_hd__and2_2_wrapper
Xdummy_bl_pulldown
+ dummy_bl
+ wbl_pulldown_en
+ vss
+ vss
+ mos_w420_l150_m1_nf1_id0
.ends control_logic_replica_v2

.subckt dff_array_9
+ vdd
+ vss
+ clk
+ d[0]
+ d[1]
+ d[2]
+ d[3]
+ d[4]
+ d[5]
+ d[6]
+ d[7]
+ d[8]
+ q[0]
+ q[1]
+ q[2]
+ q[3]
+ q[4]
+ q[5]
+ q[6]
+ q[7]
+ q[8]
+ qn[0]
+ qn[1]
+ qn[2]
+ qn[3]
+ qn[4]
+ qn[5]
+ qn[6]
+ qn[7]
+ qn[8]

Xdff_0
+ vdd
+ vss
+ clk
+ d[0]
+ q[0]
+ qn[0]
+ openram_dff_wrapper
Xdff_1
+ vdd
+ vss
+ clk
+ d[1]
+ q[1]
+ qn[1]
+ openram_dff_wrapper
Xdff_2
+ vdd
+ vss
+ clk
+ d[2]
+ q[2]
+ qn[2]
+ openram_dff_wrapper
Xdff_3
+ vdd
+ vss
+ clk
+ d[3]
+ q[3]
+ qn[3]
+ openram_dff_wrapper
Xdff_4
+ vdd
+ vss
+ clk
+ d[4]
+ q[4]
+ qn[4]
+ openram_dff_wrapper
Xdff_5
+ vdd
+ vss
+ clk
+ d[5]
+ q[5]
+ qn[5]
+ openram_dff_wrapper
Xdff_6
+ vdd
+ vss
+ clk
+ d[6]
+ q[6]
+ qn[6]
+ openram_dff_wrapper
Xdff_7
+ vdd
+ vss
+ clk
+ d[7]
+ q[7]
+ qn[7]
+ openram_dff_wrapper
Xdff_8
+ vdd
+ vss
+ clk
+ d[8]
+ q[8]
+ qn[8]
+ openram_dff_wrapper
.ends dff_array_9

.subckt sp_cell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]

Xcell_0_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_0
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_0
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_1
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_1
+ vdd
+ vdd
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_2
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_2
+ vdd
+ vdd
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_3
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_3
+ vdd
+ vdd
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_4
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_4
+ vdd
+ vdd
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_5
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_5
+ vdd
+ vdd
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_6
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_6
+ vdd
+ vdd
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_7
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_7
+ vdd
+ vdd
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_8
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_8
+ vdd
+ vdd
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_9
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_9
+ vdd
+ vdd
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_10
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_10
+ vdd
+ vdd
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_11
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_11
+ vdd
+ vdd
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_12
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_12
+ vdd
+ vdd
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_13
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_13
+ vdd
+ vdd
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_14
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_14
+ vdd
+ vdd
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_15
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_15
+ vdd
+ vdd
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_16
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_16
+ vdd
+ vdd
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_17
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_17
+ vdd
+ vdd
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_18
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_18
+ vdd
+ vdd
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_19
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_19
+ vdd
+ vdd
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_20
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_20
+ vdd
+ vdd
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_21
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_21
+ vdd
+ vdd
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_22
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_22
+ vdd
+ vdd
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_23
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_23
+ vdd
+ vdd
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_24
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_24
+ vdd
+ vdd
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_25
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_25
+ vdd
+ vdd
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_26
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_26
+ vdd
+ vdd
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_27
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_27
+ vdd
+ vdd
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_28
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_28
+ vdd
+ vdd
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_29
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_29
+ vdd
+ vdd
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_30
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_30
+ vdd
+ vdd
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_31
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_31
+ vdd
+ vdd
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_32
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_32
+ vdd
+ vdd
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_33
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_33
+ vdd
+ vdd
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_34
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_34
+ vdd
+ vdd
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_35
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_35
+ vdd
+ vdd
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_36
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_36
+ vdd
+ vdd
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_37
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_37
+ vdd
+ vdd
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_38
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_38
+ vdd
+ vdd
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_39
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_39
+ vdd
+ vdd
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_40
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_40
+ vdd
+ vdd
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_41
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_41
+ vdd
+ vdd
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_42
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_42
+ vdd
+ vdd
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_43
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_43
+ vdd
+ vdd
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_44
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_44
+ vdd
+ vdd
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_45
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_45
+ vdd
+ vdd
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_46
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_46
+ vdd
+ vdd
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_47
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_47
+ vdd
+ vdd
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_48
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_48
+ vdd
+ vdd
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_49
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_49
+ vdd
+ vdd
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_50
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_50
+ vdd
+ vdd
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_51
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_51
+ vdd
+ vdd
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_52
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_52
+ vdd
+ vdd
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_53
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_53
+ vdd
+ vdd
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_54
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_54
+ vdd
+ vdd
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_55
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_55
+ vdd
+ vdd
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_56
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_56
+ vdd
+ vdd
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_57
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_57
+ vdd
+ vdd
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_58
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_58
+ vdd
+ vdd
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_59
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_59
+ vdd
+ vdd
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_60
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_60
+ vdd
+ vdd
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_61
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_61
+ vdd
+ vdd
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_62
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_62
+ vdd
+ vdd
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_63
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_63
+ vdd
+ vdd
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_64
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_64
+ vdd
+ vdd
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_65
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_65
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcolend_top_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
.ends sp_cell_array

.subckt replica_cell_array
+ vdd
+ vss
+ rbl
+ rbr
+ rwl

Xcell_0_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_0_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_1_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_1_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_4_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_4_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_5_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_5_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_6_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_6_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_7_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_7_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_8_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_8_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_9_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_9_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_10_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_10_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_11_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_11_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcolend_0_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_0_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
.ends replica_cell_array

.subckt col_peripherals
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]

Xwmask_dffs
+ vdd
+ vss
+ clk
+ wmask[0]
+ wmask[1]
+ wmask[2]
+ wmask[3]
+ wmask_in[0]
+ wmask_in[1]
+ wmask_in[2]
+ wmask_in[3]
+ wmask_in_b[0]
+ wmask_in_b[1]
+ wmask_in_b[2]
+ wmask_in_b[3]
+ dff_array_4
Xcol_group_0
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[0]
+ dout[0]
+ sense_en
+ column
Xcol_group_1
+ clk
+ vdd
+ vss
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[1]
+ dout[1]
+ sense_en
+ column
Xcol_group_2
+ clk
+ vdd
+ vss
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[2]
+ dout[2]
+ sense_en
+ column
Xcol_group_3
+ clk
+ vdd
+ vss
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[3]
+ dout[3]
+ sense_en
+ column
Xcol_group_4
+ clk
+ vdd
+ vss
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[4]
+ dout[4]
+ sense_en
+ column
Xcol_group_5
+ clk
+ vdd
+ vss
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[5]
+ dout[5]
+ sense_en
+ column
Xcol_group_6
+ clk
+ vdd
+ vss
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[6]
+ dout[6]
+ sense_en
+ column
Xcol_group_7
+ clk
+ vdd
+ vss
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[0]
+ din[7]
+ dout[7]
+ sense_en
+ column
Xcol_group_8
+ clk
+ vdd
+ vss
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[8]
+ dout[8]
+ sense_en
+ column
Xcol_group_9
+ clk
+ vdd
+ vss
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[9]
+ dout[9]
+ sense_en
+ column
Xcol_group_10
+ clk
+ vdd
+ vss
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[10]
+ dout[10]
+ sense_en
+ column
Xcol_group_11
+ clk
+ vdd
+ vss
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[11]
+ dout[11]
+ sense_en
+ column
Xcol_group_12
+ clk
+ vdd
+ vss
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[12]
+ dout[12]
+ sense_en
+ column
Xcol_group_13
+ clk
+ vdd
+ vss
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[13]
+ dout[13]
+ sense_en
+ column
Xcol_group_14
+ clk
+ vdd
+ vss
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[14]
+ dout[14]
+ sense_en
+ column
Xcol_group_15
+ clk
+ vdd
+ vss
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[1]
+ din[15]
+ dout[15]
+ sense_en
+ column
Xcol_group_16
+ clk
+ vdd
+ vss
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[16]
+ dout[16]
+ sense_en
+ column
Xcol_group_17
+ clk
+ vdd
+ vss
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[17]
+ dout[17]
+ sense_en
+ column
Xcol_group_18
+ clk
+ vdd
+ vss
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[18]
+ dout[18]
+ sense_en
+ column
Xcol_group_19
+ clk
+ vdd
+ vss
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[19]
+ dout[19]
+ sense_en
+ column
Xcol_group_20
+ clk
+ vdd
+ vss
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[20]
+ dout[20]
+ sense_en
+ column
Xcol_group_21
+ clk
+ vdd
+ vss
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[21]
+ dout[21]
+ sense_en
+ column
Xcol_group_22
+ clk
+ vdd
+ vss
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[22]
+ dout[22]
+ sense_en
+ column
Xcol_group_23
+ clk
+ vdd
+ vss
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[2]
+ din[23]
+ dout[23]
+ sense_en
+ column
Xcol_group_24
+ clk
+ vdd
+ vss
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[24]
+ dout[24]
+ sense_en
+ column
Xcol_group_25
+ clk
+ vdd
+ vss
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[25]
+ dout[25]
+ sense_en
+ column
Xcol_group_26
+ clk
+ vdd
+ vss
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[26]
+ dout[26]
+ sense_en
+ column
Xcol_group_27
+ clk
+ vdd
+ vss
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[27]
+ dout[27]
+ sense_en
+ column
Xcol_group_28
+ clk
+ vdd
+ vss
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[28]
+ dout[28]
+ sense_en
+ column
Xcol_group_29
+ clk
+ vdd
+ vss
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[29]
+ dout[29]
+ sense_en
+ column
Xcol_group_30
+ clk
+ vdd
+ vss
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[30]
+ dout[30]
+ sense_en
+ column
Xcol_group_31
+ clk
+ vdd
+ vss
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in[3]
+ din[31]
+ dout[31]
+ sense_en
+ column
Xdummy_precharge
+ vdd
+ dummy_bl
+ dummy_br
+ pc_b
+ precharge
Xdummy_precharge_noconn
+ vdd
+ dummy_bl_noconn
+ dummy_br_noconn
+ pc_b
+ precharge
.ends col_peripherals

.subckt precharge
+ vdd
+ bl
+ br
+ en_b

Xbl_pull_up
+ bl
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xbr_pull_up
+ br
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xequalizer
+ bl
+ en_b
+ br
+ vdd
+ mos_w1200_l150_m1_nf1_id1
.ends precharge

.subckt and2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2

.subckt decoder_stage
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]
+ a[0]
+ a[1]
+ a[2]
+ a[3]
+ a[4]
+ a[5]
+ a[6]
+ a[7]
+ b[0]
+ b[1]
+ b[2]
+ b[3]
+ b[4]
+ b[5]
+ b[6]
+ b[7]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_2
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_2
X0_2
+ vdd
+ a[0]
+ b[2]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_2
X0_3
+ vdd
+ a[0]
+ b[3]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_2
X0_4
+ vdd
+ a[0]
+ b[4]
+ decode[4]
+ decode_b[4]
+ vss
+ and2_2
X0_5
+ vdd
+ a[0]
+ b[5]
+ decode[5]
+ decode_b[5]
+ vss
+ and2_2
X0_6
+ vdd
+ a[0]
+ b[6]
+ decode[6]
+ decode_b[6]
+ vss
+ and2_2
X0_7
+ vdd
+ a[0]
+ b[7]
+ decode[7]
+ decode_b[7]
+ vss
+ and2_2
X0_8
+ vdd
+ a[1]
+ b[0]
+ decode[8]
+ decode_b[8]
+ vss
+ and2_2
X0_9
+ vdd
+ a[1]
+ b[1]
+ decode[9]
+ decode_b[9]
+ vss
+ and2_2
X0_10
+ vdd
+ a[1]
+ b[2]
+ decode[10]
+ decode_b[10]
+ vss
+ and2_2
X0_11
+ vdd
+ a[1]
+ b[3]
+ decode[11]
+ decode_b[11]
+ vss
+ and2_2
X0_12
+ vdd
+ a[1]
+ b[4]
+ decode[12]
+ decode_b[12]
+ vss
+ and2_2
X0_13
+ vdd
+ a[1]
+ b[5]
+ decode[13]
+ decode_b[13]
+ vss
+ and2_2
X0_14
+ vdd
+ a[1]
+ b[6]
+ decode[14]
+ decode_b[14]
+ vss
+ and2_2
X0_15
+ vdd
+ a[1]
+ b[7]
+ decode[15]
+ decode_b[15]
+ vss
+ and2_2
X0_16
+ vdd
+ a[2]
+ b[0]
+ decode[16]
+ decode_b[16]
+ vss
+ and2_2
X0_17
+ vdd
+ a[2]
+ b[1]
+ decode[17]
+ decode_b[17]
+ vss
+ and2_2
X0_18
+ vdd
+ a[2]
+ b[2]
+ decode[18]
+ decode_b[18]
+ vss
+ and2_2
X0_19
+ vdd
+ a[2]
+ b[3]
+ decode[19]
+ decode_b[19]
+ vss
+ and2_2
X0_20
+ vdd
+ a[2]
+ b[4]
+ decode[20]
+ decode_b[20]
+ vss
+ and2_2
X0_21
+ vdd
+ a[2]
+ b[5]
+ decode[21]
+ decode_b[21]
+ vss
+ and2_2
X0_22
+ vdd
+ a[2]
+ b[6]
+ decode[22]
+ decode_b[22]
+ vss
+ and2_2
X0_23
+ vdd
+ a[2]
+ b[7]
+ decode[23]
+ decode_b[23]
+ vss
+ and2_2
X0_24
+ vdd
+ a[3]
+ b[0]
+ decode[24]
+ decode_b[24]
+ vss
+ and2_2
X0_25
+ vdd
+ a[3]
+ b[1]
+ decode[25]
+ decode_b[25]
+ vss
+ and2_2
X0_26
+ vdd
+ a[3]
+ b[2]
+ decode[26]
+ decode_b[26]
+ vss
+ and2_2
X0_27
+ vdd
+ a[3]
+ b[3]
+ decode[27]
+ decode_b[27]
+ vss
+ and2_2
X0_28
+ vdd
+ a[3]
+ b[4]
+ decode[28]
+ decode_b[28]
+ vss
+ and2_2
X0_29
+ vdd
+ a[3]
+ b[5]
+ decode[29]
+ decode_b[29]
+ vss
+ and2_2
X0_30
+ vdd
+ a[3]
+ b[6]
+ decode[30]
+ decode_b[30]
+ vss
+ and2_2
X0_31
+ vdd
+ a[3]
+ b[7]
+ decode[31]
+ decode_b[31]
+ vss
+ and2_2
X0_32
+ vdd
+ a[4]
+ b[0]
+ decode[32]
+ decode_b[32]
+ vss
+ and2_2
X0_33
+ vdd
+ a[4]
+ b[1]
+ decode[33]
+ decode_b[33]
+ vss
+ and2_2
X0_34
+ vdd
+ a[4]
+ b[2]
+ decode[34]
+ decode_b[34]
+ vss
+ and2_2
X0_35
+ vdd
+ a[4]
+ b[3]
+ decode[35]
+ decode_b[35]
+ vss
+ and2_2
X0_36
+ vdd
+ a[4]
+ b[4]
+ decode[36]
+ decode_b[36]
+ vss
+ and2_2
X0_37
+ vdd
+ a[4]
+ b[5]
+ decode[37]
+ decode_b[37]
+ vss
+ and2_2
X0_38
+ vdd
+ a[4]
+ b[6]
+ decode[38]
+ decode_b[38]
+ vss
+ and2_2
X0_39
+ vdd
+ a[4]
+ b[7]
+ decode[39]
+ decode_b[39]
+ vss
+ and2_2
X0_40
+ vdd
+ a[5]
+ b[0]
+ decode[40]
+ decode_b[40]
+ vss
+ and2_2
X0_41
+ vdd
+ a[5]
+ b[1]
+ decode[41]
+ decode_b[41]
+ vss
+ and2_2
X0_42
+ vdd
+ a[5]
+ b[2]
+ decode[42]
+ decode_b[42]
+ vss
+ and2_2
X0_43
+ vdd
+ a[5]
+ b[3]
+ decode[43]
+ decode_b[43]
+ vss
+ and2_2
X0_44
+ vdd
+ a[5]
+ b[4]
+ decode[44]
+ decode_b[44]
+ vss
+ and2_2
X0_45
+ vdd
+ a[5]
+ b[5]
+ decode[45]
+ decode_b[45]
+ vss
+ and2_2
X0_46
+ vdd
+ a[5]
+ b[6]
+ decode[46]
+ decode_b[46]
+ vss
+ and2_2
X0_47
+ vdd
+ a[5]
+ b[7]
+ decode[47]
+ decode_b[47]
+ vss
+ and2_2
X0_48
+ vdd
+ a[6]
+ b[0]
+ decode[48]
+ decode_b[48]
+ vss
+ and2_2
X0_49
+ vdd
+ a[6]
+ b[1]
+ decode[49]
+ decode_b[49]
+ vss
+ and2_2
X0_50
+ vdd
+ a[6]
+ b[2]
+ decode[50]
+ decode_b[50]
+ vss
+ and2_2
X0_51
+ vdd
+ a[6]
+ b[3]
+ decode[51]
+ decode_b[51]
+ vss
+ and2_2
X0_52
+ vdd
+ a[6]
+ b[4]
+ decode[52]
+ decode_b[52]
+ vss
+ and2_2
X0_53
+ vdd
+ a[6]
+ b[5]
+ decode[53]
+ decode_b[53]
+ vss
+ and2_2
X0_54
+ vdd
+ a[6]
+ b[6]
+ decode[54]
+ decode_b[54]
+ vss
+ and2_2
X0_55
+ vdd
+ a[6]
+ b[7]
+ decode[55]
+ decode_b[55]
+ vss
+ and2_2
X0_56
+ vdd
+ a[7]
+ b[0]
+ decode[56]
+ decode_b[56]
+ vss
+ and2_2
X0_57
+ vdd
+ a[7]
+ b[1]
+ decode[57]
+ decode_b[57]
+ vss
+ and2_2
X0_58
+ vdd
+ a[7]
+ b[2]
+ decode[58]
+ decode_b[58]
+ vss
+ and2_2
X0_59
+ vdd
+ a[7]
+ b[3]
+ decode[59]
+ decode_b[59]
+ vss
+ and2_2
X0_60
+ vdd
+ a[7]
+ b[4]
+ decode[60]
+ decode_b[60]
+ vss
+ and2_2
X0_61
+ vdd
+ a[7]
+ b[5]
+ decode[61]
+ decode_b[61]
+ vss
+ and2_2
X0_62
+ vdd
+ a[7]
+ b[6]
+ decode[62]
+ decode_b[62]
+ vss
+ and2_2
X0_63
+ vdd
+ a[7]
+ b[7]
+ decode[63]
+ decode_b[63]
+ vss
+ and2_2
.ends decoder_stage

.subckt decoder_stage_1
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ a[0]
+ a[1]
+ b[0]
+ b[1]
+ c[0]
+ c[1]

X0
+ vdd
+ a[0]
+ b[0]
+ c[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and3
X0_1
+ vdd
+ a[0]
+ b[0]
+ c[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and3
X0_2
+ vdd
+ a[0]
+ b[1]
+ c[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and3
X0_3
+ vdd
+ a[0]
+ b[1]
+ c[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and3
X0_4
+ vdd
+ a[1]
+ b[0]
+ c[0]
+ decode[4]
+ decode_b[4]
+ vss
+ and3
X0_5
+ vdd
+ a[1]
+ b[0]
+ c[1]
+ decode[5]
+ decode_b[5]
+ vss
+ and3
X0_6
+ vdd
+ a[1]
+ b[1]
+ c[0]
+ decode[6]
+ decode_b[6]
+ vss
+ and3
X0_7
+ vdd
+ a[1]
+ b[1]
+ c[1]
+ decode[7]
+ decode_b[7]
+ vss
+ and3
.ends decoder_stage_1

.subckt decoder_stage_2
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ a[0]
+ a[1]
+ b[0]
+ b[1]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_3
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_3
X0_2
+ vdd
+ a[1]
+ b[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_3
X0_3
+ vdd
+ a[1]
+ b[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_3
.ends decoder_stage_2

.subckt and2_1
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_1

.subckt sky130_fd_sc_hd__inv_2_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__inv_2
.ends sky130_fd_sc_hd__inv_2_wrapper

.subckt edge_detector
+ din
+ dout
+ vdd
+ vss

Xdelay_chain
+ din
+ delayed
+ vdd
+ vss
+ inv_chain_17
Xand
+ din
+ delayed
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__and2_4_wrapper
.ends edge_detector

.subckt inv_chain_8
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_8

.subckt sky130_fd_sc_hd__and2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_2
.ends sky130_fd_sc_hd__and2_2_wrapper

.subckt inv_chain_2
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_2

.subckt sr_latch
+ s
+ r
+ q
+ qb
+ vdd
+ vss

Xnor_set
+ s
+ q
+ vss
+ vss
+ vdd
+ vdd
+ qb
+ sky130_fd_sc_hd__nor2_2_wrapper
Xnor_reset
+ r
+ qb
+ vss
+ vss
+ vdd
+ vdd
+ q
+ sky130_fd_sc_hd__nor2_2_wrapper
.ends sr_latch

.subckt sky130_fd_sc_hd__mux2_2_wrapper
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__mux2_2
.ends sky130_fd_sc_hd__mux2_2_wrapper

.subckt inv_chain_24
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ x[15]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv16
+ x[15]
+ vss
+ vss
+ vdd
+ vdd
+ x[16]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv17
+ x[16]
+ vss
+ vss
+ vdd
+ vdd
+ x[17]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv18
+ x[17]
+ vss
+ vss
+ vdd
+ vdd
+ x[18]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv19
+ x[18]
+ vss
+ vss
+ vdd
+ vdd
+ x[19]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv20
+ x[19]
+ vss
+ vss
+ vdd
+ vdd
+ x[20]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv21
+ x[20]
+ vss
+ vss
+ vdd
+ vdd
+ x[21]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv22
+ x[21]
+ vss
+ vss
+ vdd
+ vdd
+ x[22]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv23
+ x[22]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_24

.subckt inv_chain_4
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_4

.subckt sky130_fd_sc_hd__bufbuf_16_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__bufbuf_16
.ends sky130_fd_sc_hd__bufbuf_16_wrapper

.subckt mos_w420_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=0.420 l=0.150 nf=1 mult=1
.ends mos_w420_l150_m1_nf1_id0

.subckt openram_dff_wrapper
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N

X0
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N
+ openram_dff
.ends openram_dff_wrapper

.subckt sram_sp_cell_wrapper
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB

X0
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB
+ sram_sp_cell
.ends sram_sp_cell_wrapper

.subckt sram_sp_colend_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_colend
.ends sram_sp_colend_wrapper

.subckt sram_sp_hstrap_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_hstrap
.ends sram_sp_hstrap_wrapper

.subckt sram_sp_cell_replica_wrapper
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL

X0
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL
+ sram_sp_cell_replica
.ends sram_sp_cell_replica_wrapper

.subckt dff_array_4
+ vdd
+ vss
+ clk
+ d[0]
+ d[1]
+ d[2]
+ d[3]
+ q[0]
+ q[1]
+ q[2]
+ q[3]
+ qn[0]
+ qn[1]
+ qn[2]
+ qn[3]

Xdff_0
+ vdd
+ vss
+ clk
+ d[0]
+ q[0]
+ qn[0]
+ openram_dff_wrapper
Xdff_1
+ vdd
+ vss
+ clk
+ d[1]
+ q[1]
+ qn[1]
+ openram_dff_wrapper
Xdff_2
+ vdd
+ vss
+ clk
+ d[2]
+ q[2]
+ qn[2]
+ openram_dff_wrapper
Xdff_3
+ vdd
+ vss
+ clk
+ d[3]
+ q[3]
+ qn[3]
+ openram_dff_wrapper
.ends dff_array_4

.subckt column
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask
+ din
+ dout
+ sense_en

Xprecharge_0
+ vdd
+ bl[0]
+ br[0]
+ pc_b
+ precharge
Xread_mux_0
+ sel_b[0]
+ bl[0]
+ br[0]
+ bl_out
+ br_out
+ vdd
+ read_mux
Xwrite_mux_0
+ we[0]
+ wmask
+ q
+ q_b
+ bl[0]
+ br[0]
+ vss
+ write_mux
Xprecharge_1
+ vdd
+ bl[1]
+ br[1]
+ pc_b
+ precharge
Xread_mux_1
+ sel_b[1]
+ bl[1]
+ br[1]
+ bl_out
+ br_out
+ vdd
+ read_mux_1
Xwrite_mux_1
+ we[1]
+ wmask
+ q
+ q_b
+ bl[1]
+ br[1]
+ vss
+ write_mux_1
Xprecharge_2
+ vdd
+ bl[2]
+ br[2]
+ pc_b
+ precharge
Xread_mux_2
+ sel_b[2]
+ bl[2]
+ br[2]
+ bl_out
+ br_out
+ vdd
+ read_mux_2
Xwrite_mux_2
+ we[2]
+ wmask
+ q
+ q_b
+ bl[2]
+ br[2]
+ vss
+ write_mux_2
Xprecharge_3
+ vdd
+ bl[3]
+ br[3]
+ pc_b
+ precharge
Xread_mux_3
+ sel_b[3]
+ bl[3]
+ br[3]
+ bl_out
+ br_out
+ vdd
+ read_mux_3
Xwrite_mux_3
+ we[3]
+ wmask
+ q
+ q_b
+ bl[3]
+ br[3]
+ vss
+ write_mux_3
Xsense_amp
+ sense_en
+ br_out
+ bl_out
+ sa_outn
+ sa_outp
+ vdd
+ vss
+ sramgen_sp_sense_amp_wrapper
Xbuf
+ vdd
+ vss
+ sa_outp
+ sa_outn
+ dout
+ diff_buf_outn
+ diff_buf
Xdff
+ vdd
+ vss
+ clk
+ din
+ q
+ q_b
+ openram_dff_wrapper
.ends column

.subckt mos_w2000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=2.000 l=0.150 nf=1 mult=1
.ends mos_w2000_l150_m1_nf1_id1

.subckt mos_w1200_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id1

.subckt nand2
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w4800_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w4800_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w1600_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w1600_l150_m1_nf1_id1
.ends nand2

.subckt inv
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w8600_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w6200_l150_m1_nf1_id0
.ends inv

.subckt and2_2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2_2

.subckt and3
+ vdd
+ a
+ b
+ c
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ c
+ yb
+ nand3
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_2
.ends and3

.subckt and2_3
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_3

.subckt nand2_1
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w10000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w10000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w8000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w8000_l150_m1_nf1_id1
.ends nand2_1

.subckt inv_1
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w10000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w8000_l150_m1_nf1_id0
.ends inv_1

.subckt inv_chain_17
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ x[15]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv16
+ x[15]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_17

.subckt sky130_fd_sc_hd__and2_4_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_4
.ends sky130_fd_sc_hd__and2_4_wrapper

.subckt sky130_fd_sc_hd__nor2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__nor2_2
.ends sky130_fd_sc_hd__nor2_2_wrapper

.subckt read_mux
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends read_mux

.subckt write_mux
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w8800_l150_m1_nf1_id0
.ends write_mux

.subckt read_mux_1
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends read_mux_1

.subckt write_mux_1
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w8800_l150_m1_nf1_id0
.ends write_mux_1

.subckt read_mux_2
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends read_mux_2

.subckt write_mux_2
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w8800_l150_m1_nf1_id0
.ends write_mux_2

.subckt read_mux_3
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends read_mux_3

.subckt write_mux_3
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w8800_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w8800_l150_m1_nf1_id0
.ends write_mux_3

.subckt sramgen_sp_sense_amp_wrapper
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS

X0
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS
+ sramgen_sp_sense_amp
.ends sramgen_sp_sense_amp_wrapper

.subckt diff_buf
+ vdd
+ vss
+ din1
+ din2
+ dout1
+ dout2

Xbuf_1
+ vdd
+ vss
+ din1
+ dout1
+ buf
Xbuf_2
+ vdd
+ vss
+ din2
+ dout2
+ buf
.ends diff_buf

.subckt mos_w4800_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=4.800 l=0.150 nf=1 mult=1
.ends mos_w4800_l150_m1_nf1_id0

.subckt mos_w1600_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.600 l=0.150 nf=1 mult=1
.ends mos_w1600_l150_m1_nf1_id1

.subckt mos_w8600_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=8.600 l=0.150 nf=1 mult=1
.ends mos_w8600_l150_m1_nf1_id1

.subckt mos_w6200_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=6.200 l=0.150 nf=1 mult=1
.ends mos_w6200_l150_m1_nf1_id0

.subckt nand3
+ vdd
+ vss
+ a
+ b
+ c
+ y

Xn1
+ x1
+ a
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
Xn2
+ x2
+ b
+ x1
+ vss
+ mos_w2400_l150_m1_nf1_id0
Xn3
+ y
+ c
+ x2
+ vss
+ mos_w2400_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w800_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w800_l150_m1_nf1_id1
Xp3
+ y
+ c
+ vdd
+ vdd
+ mos_w800_l150_m1_nf1_id1
.ends nand3

.subckt inv_2
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w4300_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w3100_l150_m1_nf1_id0
.ends inv_2

.subckt mos_w10000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=10.000 l=0.150 nf=1 mult=1
.ends mos_w10000_l150_m1_nf1_id0

.subckt mos_w8000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=8.000 l=0.150 nf=1 mult=1
.ends mos_w8000_l150_m1_nf1_id1

.subckt mos_w10000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=10.000 l=0.150 nf=1 mult=1
.ends mos_w10000_l150_m1_nf1_id1

.subckt mos_w8000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=8.000 l=0.150 nf=1 mult=1
.ends mos_w8000_l150_m1_nf1_id0

.subckt mos_w4000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=4.000 l=0.150 nf=1 mult=1
.ends mos_w4000_l150_m1_nf1_id1

.subckt mos_w8800_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=8.800 l=0.150 nf=1 mult=1
.ends mos_w8800_l150_m1_nf1_id0

.subckt buf
+ vdd
+ vss
+ din
+ dout

Xinv_1
+ vdd
+ vss
+ din
+ x
+ inv_3
Xinv_2
+ vdd
+ vss
+ x
+ dout
+ inv_3
.ends buf

.subckt mos_w2400_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=2.400 l=0.150 nf=1 mult=1
.ends mos_w2400_l150_m1_nf1_id0

.subckt mos_w800_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=0.800 l=0.150 nf=1 mult=1
.ends mos_w800_l150_m1_nf1_id1

.subckt mos_w4300_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=4.300 l=0.150 nf=1 mult=1
.ends mos_w4300_l150_m1_nf1_id1

.subckt mos_w3100_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=3.100 l=0.150 nf=1 mult=1
.ends mos_w3100_l150_m1_nf1_id0

.subckt inv_3
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1200_l150_m1_nf1_id0
.ends inv_3

.subckt mos_w1200_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id0

.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_4.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_2.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/sram_sp_colend.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/sram_sp_hstrap.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/openram_dff.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/sram_sp_cell_replica.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/sram_sp_cell.spice"
.include "/bwrcq/C/rahulkumar/personal/sram22/tech/sky130/spice/sramgen_sp_sense_amp.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/bufbuf/sky130_fd_sc_hd__bufbuf_16.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/mux2/sky130_fd_sc_hd__mux2_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_2.spice"
