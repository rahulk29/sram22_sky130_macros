* sram22_512x32m4w32
* Schematic generated by Substrate

.subckt sram22_512x32m4w32
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ addr[8]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]

X0
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ addr[8]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ sram22_inner
.ends sram22_512x32m4w32

.subckt sram22_inner
+ vdd
+ vss
+ clk
+ we
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ addr[8]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]

Xaddr_gate
+ vdd
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ addr_in[6]
+ addr_in[7]
+ addr_in[8]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ addr_in_b[6]
+ addr_in_b[7]
+ addr_in_b[8]
+ wl_en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_gated[6]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ addr_b_gated[6]
+ vss
+ addr_gate
Xdecoder
+ vdd
+ vss
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_gated[6]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ addr_b_gated[6]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]
+ wl[64]
+ wl[65]
+ wl[66]
+ wl[67]
+ wl[68]
+ wl[69]
+ wl[70]
+ wl[71]
+ wl[72]
+ wl[73]
+ wl[74]
+ wl[75]
+ wl[76]
+ wl[77]
+ wl[78]
+ wl[79]
+ wl[80]
+ wl[81]
+ wl[82]
+ wl[83]
+ wl[84]
+ wl[85]
+ wl[86]
+ wl[87]
+ wl[88]
+ wl[89]
+ wl[90]
+ wl[91]
+ wl[92]
+ wl[93]
+ wl[94]
+ wl[95]
+ wl[96]
+ wl[97]
+ wl[98]
+ wl[99]
+ wl[100]
+ wl[101]
+ wl[102]
+ wl[103]
+ wl[104]
+ wl[105]
+ wl[106]
+ wl[107]
+ wl[108]
+ wl[109]
+ wl[110]
+ wl[111]
+ wl[112]
+ wl[113]
+ wl[114]
+ wl[115]
+ wl[116]
+ wl[117]
+ wl[118]
+ wl[119]
+ wl[120]
+ wl[121]
+ wl[122]
+ wl[123]
+ wl[124]
+ wl[125]
+ wl[126]
+ wl[127]
+ wl_b[0]
+ wl_b[1]
+ wl_b[2]
+ wl_b[3]
+ wl_b[4]
+ wl_b[5]
+ wl_b[6]
+ wl_b[7]
+ wl_b[8]
+ wl_b[9]
+ wl_b[10]
+ wl_b[11]
+ wl_b[12]
+ wl_b[13]
+ wl_b[14]
+ wl_b[15]
+ wl_b[16]
+ wl_b[17]
+ wl_b[18]
+ wl_b[19]
+ wl_b[20]
+ wl_b[21]
+ wl_b[22]
+ wl_b[23]
+ wl_b[24]
+ wl_b[25]
+ wl_b[26]
+ wl_b[27]
+ wl_b[28]
+ wl_b[29]
+ wl_b[30]
+ wl_b[31]
+ wl_b[32]
+ wl_b[33]
+ wl_b[34]
+ wl_b[35]
+ wl_b[36]
+ wl_b[37]
+ wl_b[38]
+ wl_b[39]
+ wl_b[40]
+ wl_b[41]
+ wl_b[42]
+ wl_b[43]
+ wl_b[44]
+ wl_b[45]
+ wl_b[46]
+ wl_b[47]
+ wl_b[48]
+ wl_b[49]
+ wl_b[50]
+ wl_b[51]
+ wl_b[52]
+ wl_b[53]
+ wl_b[54]
+ wl_b[55]
+ wl_b[56]
+ wl_b[57]
+ wl_b[58]
+ wl_b[59]
+ wl_b[60]
+ wl_b[61]
+ wl_b[62]
+ wl_b[63]
+ wl_b[64]
+ wl_b[65]
+ wl_b[66]
+ wl_b[67]
+ wl_b[68]
+ wl_b[69]
+ wl_b[70]
+ wl_b[71]
+ wl_b[72]
+ wl_b[73]
+ wl_b[74]
+ wl_b[75]
+ wl_b[76]
+ wl_b[77]
+ wl_b[78]
+ wl_b[79]
+ wl_b[80]
+ wl_b[81]
+ wl_b[82]
+ wl_b[83]
+ wl_b[84]
+ wl_b[85]
+ wl_b[86]
+ wl_b[87]
+ wl_b[88]
+ wl_b[89]
+ wl_b[90]
+ wl_b[91]
+ wl_b[92]
+ wl_b[93]
+ wl_b[94]
+ wl_b[95]
+ wl_b[96]
+ wl_b[97]
+ wl_b[98]
+ wl_b[99]
+ wl_b[100]
+ wl_b[101]
+ wl_b[102]
+ wl_b[103]
+ wl_b[104]
+ wl_b[105]
+ wl_b[106]
+ wl_b[107]
+ wl_b[108]
+ wl_b[109]
+ wl_b[110]
+ wl_b[111]
+ wl_b[112]
+ wl_b[113]
+ wl_b[114]
+ wl_b[115]
+ wl_b[116]
+ wl_b[117]
+ wl_b[118]
+ wl_b[119]
+ wl_b[120]
+ wl_b[121]
+ wl_b[122]
+ wl_b[123]
+ wl_b[124]
+ wl_b[125]
+ wl_b[126]
+ wl_b[127]
+ decoder
Xcolumn_decoder
+ vdd
+ vss
+ addr_in[0]
+ addr_in[1]
+ addr_in_b[0]
+ addr_in_b[1]
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ decoder_1
Xwmux_driver
+ vdd
+ col_sel[0]
+ col_sel[1]
+ col_sel[2]
+ col_sel[3]
+ write_driver_en
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmux_sel_b[0]
+ wmux_sel_b[1]
+ wmux_sel_b[2]
+ wmux_sel_b[3]
+ vss
+ wmux_driver
Xcontrol_logic
+ clk
+ we_in
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss
+ control_logic_replica_v2
Xaddr_we_dffs
+ vdd
+ vss
+ clk
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr[7]
+ addr[8]
+ we
+ addr_in[0]
+ addr_in[1]
+ addr_in[2]
+ addr_in[3]
+ addr_in[4]
+ addr_in[5]
+ addr_in[6]
+ addr_in[7]
+ addr_in[8]
+ we_in
+ addr_in_b[0]
+ addr_in_b[1]
+ addr_in_b[2]
+ addr_in_b[3]
+ addr_in_b[4]
+ addr_in_b[5]
+ addr_in_b[6]
+ addr_in_b[7]
+ addr_in_b[8]
+ we_in_b
+ dff_array_10
Xbitcell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]
+ wl[64]
+ wl[65]
+ wl[66]
+ wl[67]
+ wl[68]
+ wl[69]
+ wl[70]
+ wl[71]
+ wl[72]
+ wl[73]
+ wl[74]
+ wl[75]
+ wl[76]
+ wl[77]
+ wl[78]
+ wl[79]
+ wl[80]
+ wl[81]
+ wl[82]
+ wl[83]
+ wl[84]
+ wl[85]
+ wl[86]
+ wl[87]
+ wl[88]
+ wl[89]
+ wl[90]
+ wl[91]
+ wl[92]
+ wl[93]
+ wl[94]
+ wl[95]
+ wl[96]
+ wl[97]
+ wl[98]
+ wl[99]
+ wl[100]
+ wl[101]
+ wl[102]
+ wl[103]
+ wl[104]
+ wl[105]
+ wl[106]
+ wl[107]
+ wl[108]
+ wl[109]
+ wl[110]
+ wl[111]
+ wl[112]
+ wl[113]
+ wl[114]
+ wl[115]
+ wl[116]
+ wl[117]
+ wl[118]
+ wl[119]
+ wl[120]
+ wl[121]
+ wl[122]
+ wl[123]
+ wl[124]
+ wl[125]
+ wl[126]
+ wl[127]
+ sp_cell_array
Xreplica_bitcell_array
+ vdd
+ vss
+ rbl
+ rbr
+ wl_en0
+ replica_cell_array
Xcol_circuitry
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ col_sel_b[0]
+ col_sel_b[1]
+ col_sel_b[2]
+ col_sel_b[3]
+ wmux_sel[0]
+ wmux_sel[1]
+ wmux_sel[2]
+ wmux_sel[3]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ col_peripherals
Xreplica_precharge_0
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
Xreplica_precharge_1
+ vdd
+ rbl
+ rbr
+ pc_b
+ precharge
.ends sram22_inner

.subckt addr_gate
+ vdd
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ addr_b[4]
+ addr_b[5]
+ addr_b[6]
+ en
+ addr_gated[0]
+ addr_gated[1]
+ addr_gated[2]
+ addr_gated[3]
+ addr_gated[4]
+ addr_gated[5]
+ addr_gated[6]
+ addr_b_gated[0]
+ addr_b_gated[1]
+ addr_b_gated[2]
+ addr_b_gated[3]
+ addr_b_gated[4]
+ addr_b_gated[5]
+ addr_b_gated[6]
+ vss

Xaddr_gate_0
+ vdd
+ addr[0]
+ en
+ addr_gated[0]
+ int1[0]
+ vss
+ and2
Xaddr_b_gate_0
+ vdd
+ addr_b[0]
+ en
+ addr_b_gated[0]
+ int2[0]
+ vss
+ and2
Xaddr_gate_1
+ vdd
+ addr[1]
+ en
+ addr_gated[1]
+ int1[1]
+ vss
+ and2
Xaddr_b_gate_1
+ vdd
+ addr_b[1]
+ en
+ addr_b_gated[1]
+ int2[1]
+ vss
+ and2
Xaddr_gate_2
+ vdd
+ addr[2]
+ en
+ addr_gated[2]
+ int1[2]
+ vss
+ and2
Xaddr_b_gate_2
+ vdd
+ addr_b[2]
+ en
+ addr_b_gated[2]
+ int2[2]
+ vss
+ and2
Xaddr_gate_3
+ vdd
+ addr[3]
+ en
+ addr_gated[3]
+ int1[3]
+ vss
+ and2
Xaddr_b_gate_3
+ vdd
+ addr_b[3]
+ en
+ addr_b_gated[3]
+ int2[3]
+ vss
+ and2
Xaddr_gate_4
+ vdd
+ addr[4]
+ en
+ addr_gated[4]
+ int1[4]
+ vss
+ and2
Xaddr_b_gate_4
+ vdd
+ addr_b[4]
+ en
+ addr_b_gated[4]
+ int2[4]
+ vss
+ and2
Xaddr_gate_5
+ vdd
+ addr[5]
+ en
+ addr_gated[5]
+ int1[5]
+ vss
+ and2
Xaddr_b_gate_5
+ vdd
+ addr_b[5]
+ en
+ addr_b_gated[5]
+ int2[5]
+ vss
+ and2
Xaddr_gate_6
+ vdd
+ addr[6]
+ en
+ addr_gated[6]
+ int1[6]
+ vss
+ and2
Xaddr_b_gate_6
+ vdd
+ addr_b[6]
+ en
+ addr_b_gated[6]
+ int2[6]
+ vss
+ and2
.ends addr_gate

.subckt decoder
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr[2]
+ addr[3]
+ addr[4]
+ addr[5]
+ addr[6]
+ addr_b[0]
+ addr_b[1]
+ addr_b[2]
+ addr_b[3]
+ addr_b[4]
+ addr_b[5]
+ addr_b[6]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode[64]
+ decode[65]
+ decode[66]
+ decode[67]
+ decode[68]
+ decode[69]
+ decode[70]
+ decode[71]
+ decode[72]
+ decode[73]
+ decode[74]
+ decode[75]
+ decode[76]
+ decode[77]
+ decode[78]
+ decode[79]
+ decode[80]
+ decode[81]
+ decode[82]
+ decode[83]
+ decode[84]
+ decode[85]
+ decode[86]
+ decode[87]
+ decode[88]
+ decode[89]
+ decode[90]
+ decode[91]
+ decode[92]
+ decode[93]
+ decode[94]
+ decode[95]
+ decode[96]
+ decode[97]
+ decode[98]
+ decode[99]
+ decode[100]
+ decode[101]
+ decode[102]
+ decode[103]
+ decode[104]
+ decode[105]
+ decode[106]
+ decode[107]
+ decode[108]
+ decode[109]
+ decode[110]
+ decode[111]
+ decode[112]
+ decode[113]
+ decode[114]
+ decode[115]
+ decode[116]
+ decode[117]
+ decode[118]
+ decode[119]
+ decode[120]
+ decode[121]
+ decode[122]
+ decode[123]
+ decode[124]
+ decode[125]
+ decode[126]
+ decode[127]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]
+ decode_b[64]
+ decode_b[65]
+ decode_b[66]
+ decode_b[67]
+ decode_b[68]
+ decode_b[69]
+ decode_b[70]
+ decode_b[71]
+ decode_b[72]
+ decode_b[73]
+ decode_b[74]
+ decode_b[75]
+ decode_b[76]
+ decode_b[77]
+ decode_b[78]
+ decode_b[79]
+ decode_b[80]
+ decode_b[81]
+ decode_b[82]
+ decode_b[83]
+ decode_b[84]
+ decode_b[85]
+ decode_b[86]
+ decode_b[87]
+ decode_b[88]
+ decode_b[89]
+ decode_b[90]
+ decode_b[91]
+ decode_b[92]
+ decode_b[93]
+ decode_b[94]
+ decode_b[95]
+ decode_b[96]
+ decode_b[97]
+ decode_b[98]
+ decode_b[99]
+ decode_b[100]
+ decode_b[101]
+ decode_b[102]
+ decode_b[103]
+ decode_b[104]
+ decode_b[105]
+ decode_b[106]
+ decode_b[107]
+ decode_b[108]
+ decode_b[109]
+ decode_b[110]
+ decode_b[111]
+ decode_b[112]
+ decode_b[113]
+ decode_b[114]
+ decode_b[115]
+ decode_b[116]
+ decode_b[117]
+ decode_b[118]
+ decode_b[119]
+ decode_b[120]
+ decode_b[121]
+ decode_b[122]
+ decode_b[123]
+ decode_b[124]
+ decode_b[125]
+ decode_b[126]
+ decode_b[127]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode[64]
+ decode[65]
+ decode[66]
+ decode[67]
+ decode[68]
+ decode[69]
+ decode[70]
+ decode[71]
+ decode[72]
+ decode[73]
+ decode[74]
+ decode[75]
+ decode[76]
+ decode[77]
+ decode[78]
+ decode[79]
+ decode[80]
+ decode[81]
+ decode[82]
+ decode[83]
+ decode[84]
+ decode[85]
+ decode[86]
+ decode[87]
+ decode[88]
+ decode[89]
+ decode[90]
+ decode[91]
+ decode[92]
+ decode[93]
+ decode[94]
+ decode[95]
+ decode[96]
+ decode[97]
+ decode[98]
+ decode[99]
+ decode[100]
+ decode[101]
+ decode[102]
+ decode[103]
+ decode[104]
+ decode[105]
+ decode[106]
+ decode[107]
+ decode[108]
+ decode[109]
+ decode[110]
+ decode[111]
+ decode[112]
+ decode[113]
+ decode[114]
+ decode[115]
+ decode[116]
+ decode[117]
+ decode[118]
+ decode[119]
+ decode[120]
+ decode[121]
+ decode[122]
+ decode[123]
+ decode[124]
+ decode[125]
+ decode[126]
+ decode[127]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]
+ decode_b[64]
+ decode_b[65]
+ decode_b[66]
+ decode_b[67]
+ decode_b[68]
+ decode_b[69]
+ decode_b[70]
+ decode_b[71]
+ decode_b[72]
+ decode_b[73]
+ decode_b[74]
+ decode_b[75]
+ decode_b[76]
+ decode_b[77]
+ decode_b[78]
+ decode_b[79]
+ decode_b[80]
+ decode_b[81]
+ decode_b[82]
+ decode_b[83]
+ decode_b[84]
+ decode_b[85]
+ decode_b[86]
+ decode_b[87]
+ decode_b[88]
+ decode_b[89]
+ decode_b[90]
+ decode_b[91]
+ decode_b[92]
+ decode_b[93]
+ decode_b[94]
+ decode_b[95]
+ decode_b[96]
+ decode_b[97]
+ decode_b[98]
+ decode_b[99]
+ decode_b[100]
+ decode_b[101]
+ decode_b[102]
+ decode_b[103]
+ decode_b[104]
+ decode_b[105]
+ decode_b[106]
+ decode_b[107]
+ decode_b[108]
+ decode_b[109]
+ decode_b[110]
+ decode_b[111]
+ decode_b[112]
+ decode_b[113]
+ decode_b[114]
+ decode_b[115]
+ decode_b[116]
+ decode_b[117]
+ decode_b[118]
+ decode_b[119]
+ decode_b[120]
+ decode_b[121]
+ decode_b[122]
+ decode_b[123]
+ decode_b[124]
+ decode_b[125]
+ decode_b[126]
+ decode_b[127]
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ a_1[4]
+ a_1[5]
+ a_1[6]
+ a_1[7]
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ b_1[4]
+ b_1[5]
+ b_1[6]
+ b_1[7]
+ b_1[8]
+ b_1[9]
+ b_1[10]
+ b_1[11]
+ b_1[12]
+ b_1[13]
+ b_1[14]
+ b_1[15]
+ decoder_stage
X0_1
+ vdd
+ vss
+ a_1[0]
+ a_1[1]
+ a_1[2]
+ a_1[3]
+ a_1[4]
+ a_1[5]
+ a_1[6]
+ a_1[7]
+ unused_2[0]
+ unused_2[1]
+ unused_2[2]
+ unused_2[3]
+ unused_2[4]
+ unused_2[5]
+ unused_2[6]
+ unused_2[7]
+ addr_b[6]
+ addr[6]
+ addr_b[5]
+ addr[5]
+ addr_b[4]
+ addr[4]
+ decoder_stage_1
X0_2
+ vdd
+ vss
+ b_1[0]
+ b_1[1]
+ b_1[2]
+ b_1[3]
+ b_1[4]
+ b_1[5]
+ b_1[6]
+ b_1[7]
+ b_1[8]
+ b_1[9]
+ b_1[10]
+ b_1[11]
+ b_1[12]
+ b_1[13]
+ b_1[14]
+ b_1[15]
+ unused_3[0]
+ unused_3[1]
+ unused_3[2]
+ unused_3[3]
+ unused_3[4]
+ unused_3[5]
+ unused_3[6]
+ unused_3[7]
+ unused_3[8]
+ unused_3[9]
+ unused_3[10]
+ unused_3[11]
+ unused_3[12]
+ unused_3[13]
+ unused_3[14]
+ unused_3[15]
+ a_3[0]
+ a_3[1]
+ a_3[2]
+ a_3[3]
+ b_3[0]
+ b_3[1]
+ b_3[2]
+ b_3[3]
+ decoder_stage_2
X0_3
+ vdd
+ vss
+ a_3[0]
+ a_3[1]
+ a_3[2]
+ a_3[3]
+ unused_4[0]
+ unused_4[1]
+ unused_4[2]
+ unused_4[3]
+ addr_b[3]
+ addr[3]
+ addr_b[2]
+ addr[2]
+ decoder_stage_3
X0_4
+ vdd
+ vss
+ b_3[0]
+ b_3[1]
+ b_3[2]
+ b_3[3]
+ unused_5[0]
+ unused_5[1]
+ unused_5[2]
+ unused_5[3]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_3
.ends decoder

.subckt decoder_1
+ vdd
+ vss
+ addr[0]
+ addr[1]
+ addr_b[0]
+ addr_b[1]
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]

X0
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ addr_b[1]
+ addr[1]
+ addr_b[0]
+ addr[0]
+ decoder_stage_4
.ends decoder_1

.subckt wmux_driver
+ vdd
+ in[0]
+ in[1]
+ in[2]
+ in[3]
+ en
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ vss

Xgate_0
+ vdd
+ in[0]
+ en
+ decode[0]
+ decode_b[0]
+ vss
+ and2_1
Xgate_1
+ vdd
+ in[1]
+ en
+ decode[1]
+ decode_b[1]
+ vss
+ and2_1
Xgate_2
+ vdd
+ in[2]
+ en
+ decode[2]
+ decode_b[2]
+ vss
+ and2_1
Xgate_3
+ vdd
+ in[3]
+ en
+ decode[3]
+ decode_b[3]
+ vss
+ and2_1
.ends wmux_driver

.subckt control_logic_replica_v2
+ clk
+ we
+ pc_b
+ wl_en0
+ wl_en
+ write_driver_en
+ sense_en
+ rbl
+ dummy_bl
+ vdd
+ vss

Xinv_clk
+ clk
+ vss
+ vss
+ vdd
+ vdd
+ clk_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_clk_b
+ clk_b
+ vss
+ vss
+ vdd
+ vdd
+ clk_buf
+ sky130_fd_sc_hd__inv_2_wrapper
Xclk_pulse
+ clk_buf
+ clkp
+ vdd
+ vss
+ edge_detector
Xdecoder_replica
+ clkp
+ wl_en_set
+ vdd
+ vss
+ inv_chain_4
Xinv_we
+ we
+ vss
+ vss
+ vdd
+ vdd
+ we_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv_rbl
+ rbl
+ vss
+ vss
+ vdd
+ vdd
+ rbl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xpc_read_set_buf
+ rbl_b
+ pc_read_set
+ vdd
+ vss
+ inv_chain_48
Xand_sense_en
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sense_en_set0
+ sky130_fd_sc_hd__and2_2_wrapper
Xsense_en_delay
+ sense_en_set0
+ sense_en_set
+ vdd
+ vss
+ inv_chain_48
Xwl_ctl
+ wl_en_set
+ wl_en_rst
+ wl_en0
+ wl_en0_b
+ vdd
+ vss
+ sr_latch
Xsae_ctl
+ sense_en_set
+ clkp
+ sae_int
+ sense_en_b
+ vdd
+ vss
+ sr_latch
Xpc_ctl
+ pc_set
+ clkp
+ pc
+ pc_b0
+ vdd
+ vss
+ sr_latch
Xwr_drv_ctl
+ wr_drv_set
+ wl_en_write_rst
+ write_driver_en0
+ write_driver_en_b
+ vdd
+ vss
+ sr_latch
Xmux_wl_en_rst
+ rbl_b
+ wl_en_write_rst
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wl_en_rst
+ sky130_fd_sc_hd__mux2_2_wrapper
Xmux_pc_set
+ pc_read_set
+ pc_write_set
+ we
+ vss
+ vss
+ vdd
+ vdd
+ pc_set
+ sky130_fd_sc_hd__mux2_2_wrapper
Xsae_set
+ we_b
+ rbl_b
+ vss
+ vss
+ vdd
+ vdd
+ sae_set
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set
+ clkp
+ we
+ vss
+ vss
+ vdd
+ vdd
+ wr_drv_set_undelayed
+ sky130_fd_sc_hd__and2_2_wrapper
Xwr_drv_set_decoder_delay_replica
+ wr_drv_set_undelayed
+ wr_drv_set
+ vdd
+ vss
+ inv_chain_8
Xinv_dummy_bl
+ dummy_bl
+ vss
+ vss
+ vdd
+ vdd
+ dummy_bl_b
+ sky130_fd_sc_hd__inv_2_wrapper
Xwl_en_write_rst_buf
+ dummy_bl_b
+ wl_en_write_rst
+ vdd
+ vss
+ inv_chain_4
Xpc_write_set_buf
+ wl_en_write_rst
+ pc_write_set
+ vdd
+ vss
+ inv_chain_16
Xwl_en_buf
+ wl_en0
+ vss
+ vss
+ vdd
+ vdd
+ wl_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf
+ sae_int
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xsae_buf2
+ sae_int
+ vss
+ vss
+ vdd
+ vdd
+ sense_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xpc_b_buf2
+ pc_b0
+ vss
+ vss
+ vdd
+ vdd
+ pc_b
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwr_drv_buf
+ write_driver_en0
+ vss
+ vss
+ vdd
+ vdd
+ write_driver_en
+ sky130_fd_sc_hd__bufbuf_16_wrapper
Xwbl_pulldown_en
+ wl_en
+ write_driver_en
+ vss
+ vss
+ vdd
+ vdd
+ wbl_pulldown_en
+ sky130_fd_sc_hd__and2_2_wrapper
Xdummy_bl_pulldown
+ dummy_bl
+ wbl_pulldown_en
+ vss
+ vss
+ mos_w420_l150_m1_nf1_id0
.ends control_logic_replica_v2

.subckt dff_array_10
+ vdd
+ vss
+ clk
+ d[0]
+ d[1]
+ d[2]
+ d[3]
+ d[4]
+ d[5]
+ d[6]
+ d[7]
+ d[8]
+ d[9]
+ q[0]
+ q[1]
+ q[2]
+ q[3]
+ q[4]
+ q[5]
+ q[6]
+ q[7]
+ q[8]
+ q[9]
+ qn[0]
+ qn[1]
+ qn[2]
+ qn[3]
+ qn[4]
+ qn[5]
+ qn[6]
+ qn[7]
+ qn[8]
+ qn[9]

Xdff_0
+ vdd
+ vss
+ clk
+ d[0]
+ q[0]
+ qn[0]
+ openram_dff_wrapper
Xdff_1
+ vdd
+ vss
+ clk
+ d[1]
+ q[1]
+ qn[1]
+ openram_dff_wrapper
Xdff_2
+ vdd
+ vss
+ clk
+ d[2]
+ q[2]
+ qn[2]
+ openram_dff_wrapper
Xdff_3
+ vdd
+ vss
+ clk
+ d[3]
+ q[3]
+ qn[3]
+ openram_dff_wrapper
Xdff_4
+ vdd
+ vss
+ clk
+ d[4]
+ q[4]
+ qn[4]
+ openram_dff_wrapper
Xdff_5
+ vdd
+ vss
+ clk
+ d[5]
+ q[5]
+ qn[5]
+ openram_dff_wrapper
Xdff_6
+ vdd
+ vss
+ clk
+ d[6]
+ q[6]
+ qn[6]
+ openram_dff_wrapper
Xdff_7
+ vdd
+ vss
+ clk
+ d[7]
+ q[7]
+ qn[7]
+ openram_dff_wrapper
Xdff_8
+ vdd
+ vss
+ clk
+ d[8]
+ q[8]
+ qn[8]
+ openram_dff_wrapper
Xdff_9
+ vdd
+ vss
+ clk
+ d[9]
+ q[9]
+ qn[9]
+ openram_dff_wrapper
.ends dff_array_10

.subckt sp_cell_array
+ vdd
+ vss
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ wl[0]
+ wl[1]
+ wl[2]
+ wl[3]
+ wl[4]
+ wl[5]
+ wl[6]
+ wl[7]
+ wl[8]
+ wl[9]
+ wl[10]
+ wl[11]
+ wl[12]
+ wl[13]
+ wl[14]
+ wl[15]
+ wl[16]
+ wl[17]
+ wl[18]
+ wl[19]
+ wl[20]
+ wl[21]
+ wl[22]
+ wl[23]
+ wl[24]
+ wl[25]
+ wl[26]
+ wl[27]
+ wl[28]
+ wl[29]
+ wl[30]
+ wl[31]
+ wl[32]
+ wl[33]
+ wl[34]
+ wl[35]
+ wl[36]
+ wl[37]
+ wl[38]
+ wl[39]
+ wl[40]
+ wl[41]
+ wl[42]
+ wl[43]
+ wl[44]
+ wl[45]
+ wl[46]
+ wl[47]
+ wl[48]
+ wl[49]
+ wl[50]
+ wl[51]
+ wl[52]
+ wl[53]
+ wl[54]
+ wl[55]
+ wl[56]
+ wl[57]
+ wl[58]
+ wl[59]
+ wl[60]
+ wl[61]
+ wl[62]
+ wl[63]
+ wl[64]
+ wl[65]
+ wl[66]
+ wl[67]
+ wl[68]
+ wl[69]
+ wl[70]
+ wl[71]
+ wl[72]
+ wl[73]
+ wl[74]
+ wl[75]
+ wl[76]
+ wl[77]
+ wl[78]
+ wl[79]
+ wl[80]
+ wl[81]
+ wl[82]
+ wl[83]
+ wl[84]
+ wl[85]
+ wl[86]
+ wl[87]
+ wl[88]
+ wl[89]
+ wl[90]
+ wl[91]
+ wl[92]
+ wl[93]
+ wl[94]
+ wl[95]
+ wl[96]
+ wl[97]
+ wl[98]
+ wl[99]
+ wl[100]
+ wl[101]
+ wl[102]
+ wl[103]
+ wl[104]
+ wl[105]
+ wl[106]
+ wl[107]
+ wl[108]
+ wl[109]
+ wl[110]
+ wl[111]
+ wl[112]
+ wl[113]
+ wl[114]
+ wl[115]
+ wl[116]
+ wl[117]
+ wl[118]
+ wl[119]
+ wl[120]
+ wl[121]
+ wl[122]
+ wl[123]
+ wl[124]
+ wl[125]
+ wl[126]
+ wl[127]

Xcell_0_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_0_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_1_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_2_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_3_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_4_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_5_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_6_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_7_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_8_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_9_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_10_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_11_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_12_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_13_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_14_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_15_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_16_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_17_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_18_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_19_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_20_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_21_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_22_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_23_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_24_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_25_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_26_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_27_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_28_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_29_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_30_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_31_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_32_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_33_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_34_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_35_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_36_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_37_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_38_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_39_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_40_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_41_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_42_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_43_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_44_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_45_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_46_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_47_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_48_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_49_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_50_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_51_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_52_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_53_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_54_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_55_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_56_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_57_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_58_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_59_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_60_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_61_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_62_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_63_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_64_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_65_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_66_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_67_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_68_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_69_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_70_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_71_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_72_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_73_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_74_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_75_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_76_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_77_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_78_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_79_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_80_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_81_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_82_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_83_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_84_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_85_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_86_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_87_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_88_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_89_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_90_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_91_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_92_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_93_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_94_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_95_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_96_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_97_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_98_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_99_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_100_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_101_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_102_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_103_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_104_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_105_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_106_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_107_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_108_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_109_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_110_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_111_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_112_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_113_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_114_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_115_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_116_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_117_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_118_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_119_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_120_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_121_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_122_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_123_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_124_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_125_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_126_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcell_127_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_0
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_0
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_1
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_1
+ vdd
+ vdd
+ vdd
+ vss
+ wl[0]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_2
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_2
+ vdd
+ vdd
+ vdd
+ vss
+ wl[1]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_3
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_3
+ vdd
+ vdd
+ vdd
+ vss
+ wl[2]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_4
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_4
+ vdd
+ vdd
+ vdd
+ vss
+ wl[3]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_5
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_5
+ vdd
+ vdd
+ vdd
+ vss
+ wl[4]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_6
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_6
+ vdd
+ vdd
+ vdd
+ vss
+ wl[5]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_7
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_7
+ vdd
+ vdd
+ vdd
+ vss
+ wl[6]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_8
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_8
+ vdd
+ vdd
+ vdd
+ vss
+ wl[7]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_9
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_9
+ vdd
+ vdd
+ vdd
+ vss
+ wl[8]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_10
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_10
+ vdd
+ vdd
+ vdd
+ vss
+ wl[9]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_11
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_11
+ vdd
+ vdd
+ vdd
+ vss
+ wl[10]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_12
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_12
+ vdd
+ vdd
+ vdd
+ vss
+ wl[11]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_13
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_13
+ vdd
+ vdd
+ vdd
+ vss
+ wl[12]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_14
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_14
+ vdd
+ vdd
+ vdd
+ vss
+ wl[13]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_15
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_15
+ vdd
+ vdd
+ vdd
+ vss
+ wl[14]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_16
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_16
+ vdd
+ vdd
+ vdd
+ vss
+ wl[15]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_17
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_17
+ vdd
+ vdd
+ vdd
+ vss
+ wl[16]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_18
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_18
+ vdd
+ vdd
+ vdd
+ vss
+ wl[17]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_19
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_19
+ vdd
+ vdd
+ vdd
+ vss
+ wl[18]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_20
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_20
+ vdd
+ vdd
+ vdd
+ vss
+ wl[19]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_21
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_21
+ vdd
+ vdd
+ vdd
+ vss
+ wl[20]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_22
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_22
+ vdd
+ vdd
+ vdd
+ vss
+ wl[21]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_23
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_23
+ vdd
+ vdd
+ vdd
+ vss
+ wl[22]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_24
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_24
+ vdd
+ vdd
+ vdd
+ vss
+ wl[23]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_25
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_25
+ vdd
+ vdd
+ vdd
+ vss
+ wl[24]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_26
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_26
+ vdd
+ vdd
+ vdd
+ vss
+ wl[25]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_27
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_27
+ vdd
+ vdd
+ vdd
+ vss
+ wl[26]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_28
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_28
+ vdd
+ vdd
+ vdd
+ vss
+ wl[27]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_29
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_29
+ vdd
+ vdd
+ vdd
+ vss
+ wl[28]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_30
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_30
+ vdd
+ vdd
+ vdd
+ vss
+ wl[29]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_31
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_31
+ vdd
+ vdd
+ vdd
+ vss
+ wl[30]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_32
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_32
+ vdd
+ vdd
+ vdd
+ vss
+ wl[31]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_33
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_33
+ vdd
+ vdd
+ vdd
+ vss
+ wl[32]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_34
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_34
+ vdd
+ vdd
+ vdd
+ vss
+ wl[33]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_35
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_35
+ vdd
+ vdd
+ vdd
+ vss
+ wl[34]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_36
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_36
+ vdd
+ vdd
+ vdd
+ vss
+ wl[35]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_37
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_37
+ vdd
+ vdd
+ vdd
+ vss
+ wl[36]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_38
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_38
+ vdd
+ vdd
+ vdd
+ vss
+ wl[37]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_39
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_39
+ vdd
+ vdd
+ vdd
+ vss
+ wl[38]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_40
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_40
+ vdd
+ vdd
+ vdd
+ vss
+ wl[39]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_41
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_41
+ vdd
+ vdd
+ vdd
+ vss
+ wl[40]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_42
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_42
+ vdd
+ vdd
+ vdd
+ vss
+ wl[41]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_43
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_43
+ vdd
+ vdd
+ vdd
+ vss
+ wl[42]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_44
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_44
+ vdd
+ vdd
+ vdd
+ vss
+ wl[43]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_45
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_45
+ vdd
+ vdd
+ vdd
+ vss
+ wl[44]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_46
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_46
+ vdd
+ vdd
+ vdd
+ vss
+ wl[45]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_47
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_47
+ vdd
+ vdd
+ vdd
+ vss
+ wl[46]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_48
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_48
+ vdd
+ vdd
+ vdd
+ vss
+ wl[47]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_49
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_49
+ vdd
+ vdd
+ vdd
+ vss
+ wl[48]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_50
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_50
+ vdd
+ vdd
+ vdd
+ vss
+ wl[49]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_51
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_51
+ vdd
+ vdd
+ vdd
+ vss
+ wl[50]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_52
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_52
+ vdd
+ vdd
+ vdd
+ vss
+ wl[51]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_53
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_53
+ vdd
+ vdd
+ vdd
+ vss
+ wl[52]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_54
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_54
+ vdd
+ vdd
+ vdd
+ vss
+ wl[53]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_55
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_55
+ vdd
+ vdd
+ vdd
+ vss
+ wl[54]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_56
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_56
+ vdd
+ vdd
+ vdd
+ vss
+ wl[55]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_57
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_57
+ vdd
+ vdd
+ vdd
+ vss
+ wl[56]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_58
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_58
+ vdd
+ vdd
+ vdd
+ vss
+ wl[57]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_59
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_59
+ vdd
+ vdd
+ vdd
+ vss
+ wl[58]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_60
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_60
+ vdd
+ vdd
+ vdd
+ vss
+ wl[59]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_61
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_61
+ vdd
+ vdd
+ vdd
+ vss
+ wl[60]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_62
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_62
+ vdd
+ vdd
+ vdd
+ vss
+ wl[61]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_63
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_63
+ vdd
+ vdd
+ vdd
+ vss
+ wl[62]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_64
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_64
+ vdd
+ vdd
+ vdd
+ vss
+ wl[63]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_65
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_65
+ vdd
+ vdd
+ vdd
+ vss
+ wl[64]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_66
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_66
+ vdd
+ vdd
+ vdd
+ vss
+ wl[65]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_67
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_67
+ vdd
+ vdd
+ vdd
+ vss
+ wl[66]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_68
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_68
+ vdd
+ vdd
+ vdd
+ vss
+ wl[67]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_69
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_69
+ vdd
+ vdd
+ vdd
+ vss
+ wl[68]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_70
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_70
+ vdd
+ vdd
+ vdd
+ vss
+ wl[69]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_71
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_71
+ vdd
+ vdd
+ vdd
+ vss
+ wl[70]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_72
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_72
+ vdd
+ vdd
+ vdd
+ vss
+ wl[71]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_73
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_73
+ vdd
+ vdd
+ vdd
+ vss
+ wl[72]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_74
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_74
+ vdd
+ vdd
+ vdd
+ vss
+ wl[73]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_75
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_75
+ vdd
+ vdd
+ vdd
+ vss
+ wl[74]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_76
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_76
+ vdd
+ vdd
+ vdd
+ vss
+ wl[75]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_77
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_77
+ vdd
+ vdd
+ vdd
+ vss
+ wl[76]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_78
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_78
+ vdd
+ vdd
+ vdd
+ vss
+ wl[77]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_79
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_79
+ vdd
+ vdd
+ vdd
+ vss
+ wl[78]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_80
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_80
+ vdd
+ vdd
+ vdd
+ vss
+ wl[79]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_81
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_81
+ vdd
+ vdd
+ vdd
+ vss
+ wl[80]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_82
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_82
+ vdd
+ vdd
+ vdd
+ vss
+ wl[81]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_83
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_83
+ vdd
+ vdd
+ vdd
+ vss
+ wl[82]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_84
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_84
+ vdd
+ vdd
+ vdd
+ vss
+ wl[83]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_85
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_85
+ vdd
+ vdd
+ vdd
+ vss
+ wl[84]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_86
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_86
+ vdd
+ vdd
+ vdd
+ vss
+ wl[85]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_87
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_87
+ vdd
+ vdd
+ vdd
+ vss
+ wl[86]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_88
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_88
+ vdd
+ vdd
+ vdd
+ vss
+ wl[87]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_89
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_89
+ vdd
+ vdd
+ vdd
+ vss
+ wl[88]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_90
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_90
+ vdd
+ vdd
+ vdd
+ vss
+ wl[89]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_91
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_91
+ vdd
+ vdd
+ vdd
+ vss
+ wl[90]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_92
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_92
+ vdd
+ vdd
+ vdd
+ vss
+ wl[91]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_93
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_93
+ vdd
+ vdd
+ vdd
+ vss
+ wl[92]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_94
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_94
+ vdd
+ vdd
+ vdd
+ vss
+ wl[93]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_95
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_95
+ vdd
+ vdd
+ vdd
+ vss
+ wl[94]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_96
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_96
+ vdd
+ vdd
+ vdd
+ vss
+ wl[95]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_97
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_97
+ vdd
+ vdd
+ vdd
+ vss
+ wl[96]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_98
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_98
+ vdd
+ vdd
+ vdd
+ vss
+ wl[97]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_99
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_99
+ vdd
+ vdd
+ vdd
+ vss
+ wl[98]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_100
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_100
+ vdd
+ vdd
+ vdd
+ vss
+ wl[99]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_101
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_101
+ vdd
+ vdd
+ vdd
+ vss
+ wl[100]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_102
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_102
+ vdd
+ vdd
+ vdd
+ vss
+ wl[101]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_103
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_103
+ vdd
+ vdd
+ vdd
+ vss
+ wl[102]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_104
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_104
+ vdd
+ vdd
+ vdd
+ vss
+ wl[103]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_105
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_105
+ vdd
+ vdd
+ vdd
+ vss
+ wl[104]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_106
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_106
+ vdd
+ vdd
+ vdd
+ vss
+ wl[105]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_107
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_107
+ vdd
+ vdd
+ vdd
+ vss
+ wl[106]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_108
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_108
+ vdd
+ vdd
+ vdd
+ vss
+ wl[107]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_109
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_109
+ vdd
+ vdd
+ vdd
+ vss
+ wl[108]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_110
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_110
+ vdd
+ vdd
+ vdd
+ vss
+ wl[109]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_111
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_111
+ vdd
+ vdd
+ vdd
+ vss
+ wl[110]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_112
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_112
+ vdd
+ vdd
+ vdd
+ vss
+ wl[111]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_113
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_113
+ vdd
+ vdd
+ vdd
+ vss
+ wl[112]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_114
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_114
+ vdd
+ vdd
+ vdd
+ vss
+ wl[113]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_115
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_115
+ vdd
+ vdd
+ vdd
+ vss
+ wl[114]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_116
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_116
+ vdd
+ vdd
+ vdd
+ vss
+ wl[115]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_117
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_117
+ vdd
+ vdd
+ vdd
+ vss
+ wl[116]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_118
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_118
+ vdd
+ vdd
+ vdd
+ vss
+ wl[117]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_119
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_119
+ vdd
+ vdd
+ vdd
+ vss
+ wl[118]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_120
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_120
+ vdd
+ vdd
+ vdd
+ vss
+ wl[119]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_121
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_121
+ vdd
+ vdd
+ vdd
+ vss
+ wl[120]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_122
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_122
+ vdd
+ vdd
+ vdd
+ vss
+ wl[121]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_123
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_123
+ vdd
+ vdd
+ vdd
+ vss
+ wl[122]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_124
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_124
+ vdd
+ vdd
+ vdd
+ vss
+ wl[123]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_125
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_125
+ vdd
+ vdd
+ vdd
+ vss
+ wl[124]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_126
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_126
+ vdd
+ vdd
+ vdd
+ vss
+ wl[125]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_127
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_127
+ vdd
+ vdd
+ vdd
+ vss
+ wl[126]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_128
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_128
+ vdd
+ vdd
+ vdd
+ vss
+ wl[127]
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_left_129
+ dummy_bl
+ dummy_br
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_col_right_129
+ vdd
+ vdd
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_0
+ bl[0]
+ br[0]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_1
+ bl[1]
+ br[1]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_2
+ bl[2]
+ br[2]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_3
+ bl[3]
+ br[3]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_4
+ bl[4]
+ br[4]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_5
+ bl[5]
+ br[5]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_6
+ bl[6]
+ br[6]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_7
+ bl[7]
+ br[7]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_8
+ bl[8]
+ br[8]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_9
+ bl[9]
+ br[9]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_10
+ bl[10]
+ br[10]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_11
+ bl[11]
+ br[11]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_12
+ bl[12]
+ br[12]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_13
+ bl[13]
+ br[13]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_14
+ bl[14]
+ br[14]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_15
+ bl[15]
+ br[15]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_16
+ bl[16]
+ br[16]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_17
+ bl[17]
+ br[17]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_18
+ bl[18]
+ br[18]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_19
+ bl[19]
+ br[19]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_20
+ bl[20]
+ br[20]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_21
+ bl[21]
+ br[21]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_22
+ bl[22]
+ br[22]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_23
+ bl[23]
+ br[23]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_24
+ bl[24]
+ br[24]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_25
+ bl[25]
+ br[25]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_26
+ bl[26]
+ br[26]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_27
+ bl[27]
+ br[27]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_28
+ bl[28]
+ br[28]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_29
+ bl[29]
+ br[29]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_30
+ bl[30]
+ br[30]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_31
+ bl[31]
+ br[31]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_32
+ bl[32]
+ br[32]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_33
+ bl[33]
+ br[33]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_34
+ bl[34]
+ br[34]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_35
+ bl[35]
+ br[35]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_36
+ bl[36]
+ br[36]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_37
+ bl[37]
+ br[37]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_38
+ bl[38]
+ br[38]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_39
+ bl[39]
+ br[39]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_40
+ bl[40]
+ br[40]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_41
+ bl[41]
+ br[41]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_42
+ bl[42]
+ br[42]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_43
+ bl[43]
+ br[43]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_44
+ bl[44]
+ br[44]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_45
+ bl[45]
+ br[45]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_46
+ bl[46]
+ br[46]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_47
+ bl[47]
+ br[47]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_48
+ bl[48]
+ br[48]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_49
+ bl[49]
+ br[49]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_50
+ bl[50]
+ br[50]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_51
+ bl[51]
+ br[51]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_52
+ bl[52]
+ br[52]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_53
+ bl[53]
+ br[53]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_54
+ bl[54]
+ br[54]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_55
+ bl[55]
+ br[55]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_56
+ bl[56]
+ br[56]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_57
+ bl[57]
+ br[57]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_58
+ bl[58]
+ br[58]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_59
+ bl[59]
+ br[59]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_60
+ bl[60]
+ br[60]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_61
+ bl[61]
+ br[61]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_62
+ bl[62]
+ br[62]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_63
+ bl[63]
+ br[63]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_64
+ bl[64]
+ br[64]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_65
+ bl[65]
+ br[65]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_66
+ bl[66]
+ br[66]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_67
+ bl[67]
+ br[67]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_68
+ bl[68]
+ br[68]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_69
+ bl[69]
+ br[69]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_70
+ bl[70]
+ br[70]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_71
+ bl[71]
+ br[71]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_72
+ bl[72]
+ br[72]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_73
+ bl[73]
+ br[73]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_74
+ bl[74]
+ br[74]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_75
+ bl[75]
+ br[75]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_76
+ bl[76]
+ br[76]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_77
+ bl[77]
+ br[77]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_78
+ bl[78]
+ br[78]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_79
+ bl[79]
+ br[79]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_80
+ bl[80]
+ br[80]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_81
+ bl[81]
+ br[81]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_82
+ bl[82]
+ br[82]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_83
+ bl[83]
+ br[83]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_84
+ bl[84]
+ br[84]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_85
+ bl[85]
+ br[85]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_86
+ bl[86]
+ br[86]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_87
+ bl[87]
+ br[87]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_88
+ bl[88]
+ br[88]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_89
+ bl[89]
+ br[89]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_90
+ bl[90]
+ br[90]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_91
+ bl[91]
+ br[91]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_92
+ bl[92]
+ br[92]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_93
+ bl[93]
+ br[93]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_94
+ bl[94]
+ br[94]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_95
+ bl[95]
+ br[95]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_96
+ bl[96]
+ br[96]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_97
+ bl[97]
+ br[97]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_98
+ bl[98]
+ br[98]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_99
+ bl[99]
+ br[99]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_100
+ bl[100]
+ br[100]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_101
+ bl[101]
+ br[101]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_102
+ bl[102]
+ br[102]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_103
+ bl[103]
+ br[103]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_104
+ bl[104]
+ br[104]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_105
+ bl[105]
+ br[105]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_106
+ bl[106]
+ br[106]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_107
+ bl[107]
+ br[107]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_108
+ bl[108]
+ br[108]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_109
+ bl[109]
+ br[109]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_110
+ bl[110]
+ br[110]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_111
+ bl[111]
+ br[111]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_112
+ bl[112]
+ br[112]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_113
+ bl[113]
+ br[113]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_114
+ bl[114]
+ br[114]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_115
+ bl[115]
+ br[115]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_116
+ bl[116]
+ br[116]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_117
+ bl[117]
+ br[117]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_118
+ bl[118]
+ br[118]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_119
+ bl[119]
+ br[119]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_120
+ bl[120]
+ br[120]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_121
+ bl[121]
+ br[121]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_122
+ bl[122]
+ br[122]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_123
+ bl[123]
+ br[123]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_124
+ bl[124]
+ br[124]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_125
+ bl[125]
+ br[125]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_126
+ bl[126]
+ br[126]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_top_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xdummy_row_bot_127
+ bl[127]
+ br[127]
+ vdd
+ vss
+ vss
+ vss
+ vdd
+ sram_sp_cell_wrapper
Xcolend_top_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_0
+ dummy_br
+ vdd
+ vss
+ dummy_bl
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_1
+ br[0]
+ vdd
+ vss
+ bl[0]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_2
+ br[1]
+ vdd
+ vss
+ bl[1]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_3
+ br[2]
+ vdd
+ vss
+ bl[2]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_4
+ br[3]
+ vdd
+ vss
+ bl[3]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_5
+ br[4]
+ vdd
+ vss
+ bl[4]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_6
+ br[5]
+ vdd
+ vss
+ bl[5]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_7
+ br[6]
+ vdd
+ vss
+ bl[6]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_8
+ br[7]
+ vdd
+ vss
+ bl[7]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_9
+ br[8]
+ vdd
+ vss
+ bl[8]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_10
+ br[9]
+ vdd
+ vss
+ bl[9]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_11
+ br[10]
+ vdd
+ vss
+ bl[10]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_12
+ br[11]
+ vdd
+ vss
+ bl[11]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_13
+ br[12]
+ vdd
+ vss
+ bl[12]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_14
+ br[13]
+ vdd
+ vss
+ bl[13]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_15
+ br[14]
+ vdd
+ vss
+ bl[14]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_16
+ br[15]
+ vdd
+ vss
+ bl[15]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_17
+ br[16]
+ vdd
+ vss
+ bl[16]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_18
+ br[17]
+ vdd
+ vss
+ bl[17]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_19
+ br[18]
+ vdd
+ vss
+ bl[18]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_20
+ br[19]
+ vdd
+ vss
+ bl[19]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_21
+ br[20]
+ vdd
+ vss
+ bl[20]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_22
+ br[21]
+ vdd
+ vss
+ bl[21]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_23
+ br[22]
+ vdd
+ vss
+ bl[22]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_24
+ br[23]
+ vdd
+ vss
+ bl[23]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_25
+ br[24]
+ vdd
+ vss
+ bl[24]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_26
+ br[25]
+ vdd
+ vss
+ bl[25]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_27
+ br[26]
+ vdd
+ vss
+ bl[26]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_28
+ br[27]
+ vdd
+ vss
+ bl[27]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_29
+ br[28]
+ vdd
+ vss
+ bl[28]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_30
+ br[29]
+ vdd
+ vss
+ bl[29]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_31
+ br[30]
+ vdd
+ vss
+ bl[30]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_32
+ br[31]
+ vdd
+ vss
+ bl[31]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_33
+ br[32]
+ vdd
+ vss
+ bl[32]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_34
+ br[33]
+ vdd
+ vss
+ bl[33]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_35
+ br[34]
+ vdd
+ vss
+ bl[34]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_36
+ br[35]
+ vdd
+ vss
+ bl[35]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_37
+ br[36]
+ vdd
+ vss
+ bl[36]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_38
+ br[37]
+ vdd
+ vss
+ bl[37]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_39
+ br[38]
+ vdd
+ vss
+ bl[38]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_40
+ br[39]
+ vdd
+ vss
+ bl[39]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_41
+ br[40]
+ vdd
+ vss
+ bl[40]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_42
+ br[41]
+ vdd
+ vss
+ bl[41]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_43
+ br[42]
+ vdd
+ vss
+ bl[42]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_44
+ br[43]
+ vdd
+ vss
+ bl[43]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_45
+ br[44]
+ vdd
+ vss
+ bl[44]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_46
+ br[45]
+ vdd
+ vss
+ bl[45]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_47
+ br[46]
+ vdd
+ vss
+ bl[46]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_48
+ br[47]
+ vdd
+ vss
+ bl[47]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_49
+ br[48]
+ vdd
+ vss
+ bl[48]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_50
+ br[49]
+ vdd
+ vss
+ bl[49]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_51
+ br[50]
+ vdd
+ vss
+ bl[50]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_52
+ br[51]
+ vdd
+ vss
+ bl[51]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_53
+ br[52]
+ vdd
+ vss
+ bl[52]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_54
+ br[53]
+ vdd
+ vss
+ bl[53]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_55
+ br[54]
+ vdd
+ vss
+ bl[54]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_56
+ br[55]
+ vdd
+ vss
+ bl[55]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_57
+ br[56]
+ vdd
+ vss
+ bl[56]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_58
+ br[57]
+ vdd
+ vss
+ bl[57]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_59
+ br[58]
+ vdd
+ vss
+ bl[58]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_60
+ br[59]
+ vdd
+ vss
+ bl[59]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_61
+ br[60]
+ vdd
+ vss
+ bl[60]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_62
+ br[61]
+ vdd
+ vss
+ bl[61]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_63
+ br[62]
+ vdd
+ vss
+ bl[62]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_64
+ br[63]
+ vdd
+ vss
+ bl[63]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_65
+ br[64]
+ vdd
+ vss
+ bl[64]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_66
+ br[65]
+ vdd
+ vss
+ bl[65]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_67
+ br[66]
+ vdd
+ vss
+ bl[66]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_68
+ br[67]
+ vdd
+ vss
+ bl[67]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_69
+ br[68]
+ vdd
+ vss
+ bl[68]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_70
+ br[69]
+ vdd
+ vss
+ bl[69]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_71
+ br[70]
+ vdd
+ vss
+ bl[70]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_72
+ br[71]
+ vdd
+ vss
+ bl[71]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_73
+ br[72]
+ vdd
+ vss
+ bl[72]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_74
+ br[73]
+ vdd
+ vss
+ bl[73]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_75
+ br[74]
+ vdd
+ vss
+ bl[74]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_76
+ br[75]
+ vdd
+ vss
+ bl[75]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_77
+ br[76]
+ vdd
+ vss
+ bl[76]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_78
+ br[77]
+ vdd
+ vss
+ bl[77]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_79
+ br[78]
+ vdd
+ vss
+ bl[78]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_80
+ br[79]
+ vdd
+ vss
+ bl[79]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_81
+ br[80]
+ vdd
+ vss
+ bl[80]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_82
+ br[81]
+ vdd
+ vss
+ bl[81]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_83
+ br[82]
+ vdd
+ vss
+ bl[82]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_84
+ br[83]
+ vdd
+ vss
+ bl[83]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_85
+ br[84]
+ vdd
+ vss
+ bl[84]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_86
+ br[85]
+ vdd
+ vss
+ bl[85]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_87
+ br[86]
+ vdd
+ vss
+ bl[86]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_88
+ br[87]
+ vdd
+ vss
+ bl[87]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_89
+ br[88]
+ vdd
+ vss
+ bl[88]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_90
+ br[89]
+ vdd
+ vss
+ bl[89]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_91
+ br[90]
+ vdd
+ vss
+ bl[90]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_92
+ br[91]
+ vdd
+ vss
+ bl[91]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_93
+ br[92]
+ vdd
+ vss
+ bl[92]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_94
+ br[93]
+ vdd
+ vss
+ bl[93]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_95
+ br[94]
+ vdd
+ vss
+ bl[94]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_96
+ br[95]
+ vdd
+ vss
+ bl[95]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_97
+ br[96]
+ vdd
+ vss
+ bl[96]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_98
+ br[97]
+ vdd
+ vss
+ bl[97]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_99
+ br[98]
+ vdd
+ vss
+ bl[98]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_100
+ br[99]
+ vdd
+ vss
+ bl[99]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_101
+ br[100]
+ vdd
+ vss
+ bl[100]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_102
+ br[101]
+ vdd
+ vss
+ bl[101]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_103
+ br[102]
+ vdd
+ vss
+ bl[102]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_104
+ br[103]
+ vdd
+ vss
+ bl[103]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_105
+ br[104]
+ vdd
+ vss
+ bl[104]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_106
+ br[105]
+ vdd
+ vss
+ bl[105]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_107
+ br[106]
+ vdd
+ vss
+ bl[106]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_108
+ br[107]
+ vdd
+ vss
+ bl[107]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_109
+ br[108]
+ vdd
+ vss
+ bl[108]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_110
+ br[109]
+ vdd
+ vss
+ bl[109]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_111
+ br[110]
+ vdd
+ vss
+ bl[110]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_112
+ br[111]
+ vdd
+ vss
+ bl[111]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_113
+ br[112]
+ vdd
+ vss
+ bl[112]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_114
+ br[113]
+ vdd
+ vss
+ bl[113]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_115
+ br[114]
+ vdd
+ vss
+ bl[114]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_116
+ br[115]
+ vdd
+ vss
+ bl[115]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_117
+ br[116]
+ vdd
+ vss
+ bl[116]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_118
+ br[117]
+ vdd
+ vss
+ bl[117]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_119
+ br[118]
+ vdd
+ vss
+ bl[118]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_120
+ br[119]
+ vdd
+ vss
+ bl[119]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_121
+ br[120]
+ vdd
+ vss
+ bl[120]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_122
+ br[121]
+ vdd
+ vss
+ bl[121]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_123
+ br[122]
+ vdd
+ vss
+ bl[122]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_124
+ br[123]
+ vdd
+ vss
+ bl[123]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_125
+ br[124]
+ vdd
+ vss
+ bl[124]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_126
+ br[125]
+ vdd
+ vss
+ bl[125]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_127
+ br[126]
+ vdd
+ vss
+ bl[126]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_128
+ br[127]
+ vdd
+ vss
+ bl[127]
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xcolend_top_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_bot_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xhstrap_0_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_1_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_2_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_3_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_4_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_5_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_6_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_7_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_8_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_9_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_10_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_11_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_12_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_13_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_14_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_15_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
Xhstrap_16_129
+ vdd
+ vdd
+ vss
+ vdd
+ vss
+ vdd
+ sram_sp_hstrap_wrapper
.ends sp_cell_array

.subckt replica_cell_array
+ vdd
+ vss
+ rbl
+ rbr
+ rwl

Xcell_0_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_0_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ rwl
+ sram_sp_cell_replica_wrapper
Xcell_1_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_1_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_2_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_3_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_4_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_4_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_5_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_5_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_6_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_6_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_7_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_7_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_8_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_8_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_9_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_9_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_10_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_10_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_11_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_11_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_12_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_12_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_13_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_13_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_14_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_14_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_15_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_15_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_16_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_16_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_17_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_17_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_18_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_18_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_19_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_19_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_20_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_20_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_21_0
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcell_21_1
+ rbl
+ rbr
+ vss
+ vdd
+ vdd
+ vss
+ vss
+ sram_sp_cell_replica_wrapper
Xcolend_0_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_0
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_0_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
Xcolend_1_1
+ rbr
+ vdd
+ vss
+ rbl
+ vss
+ vdd
+ sram_sp_colend_wrapper
.ends replica_cell_array

.subckt col_peripherals
+ clk
+ vdd
+ vss
+ sense_en
+ dummy_bl
+ dummy_br
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask
+ din[0]
+ din[1]
+ din[2]
+ din[3]
+ din[4]
+ din[5]
+ din[6]
+ din[7]
+ din[8]
+ din[9]
+ din[10]
+ din[11]
+ din[12]
+ din[13]
+ din[14]
+ din[15]
+ din[16]
+ din[17]
+ din[18]
+ din[19]
+ din[20]
+ din[21]
+ din[22]
+ din[23]
+ din[24]
+ din[25]
+ din[26]
+ din[27]
+ din[28]
+ din[29]
+ din[30]
+ din[31]
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]

Xwmask_dffs
+ vdd
+ vss
+ clk
+ wmask
+ wmask_in
+ wmask_in_b
+ dff_array_1
Xcol_group_0
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[0]
+ dout[0]
+ sense_en
+ column
Xcol_group_1
+ clk
+ vdd
+ vss
+ bl[4]
+ bl[5]
+ bl[6]
+ bl[7]
+ br[4]
+ br[5]
+ br[6]
+ br[7]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[1]
+ dout[1]
+ sense_en
+ column
Xcol_group_2
+ clk
+ vdd
+ vss
+ bl[8]
+ bl[9]
+ bl[10]
+ bl[11]
+ br[8]
+ br[9]
+ br[10]
+ br[11]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[2]
+ dout[2]
+ sense_en
+ column
Xcol_group_3
+ clk
+ vdd
+ vss
+ bl[12]
+ bl[13]
+ bl[14]
+ bl[15]
+ br[12]
+ br[13]
+ br[14]
+ br[15]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[3]
+ dout[3]
+ sense_en
+ column
Xcol_group_4
+ clk
+ vdd
+ vss
+ bl[16]
+ bl[17]
+ bl[18]
+ bl[19]
+ br[16]
+ br[17]
+ br[18]
+ br[19]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[4]
+ dout[4]
+ sense_en
+ column
Xcol_group_5
+ clk
+ vdd
+ vss
+ bl[20]
+ bl[21]
+ bl[22]
+ bl[23]
+ br[20]
+ br[21]
+ br[22]
+ br[23]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[5]
+ dout[5]
+ sense_en
+ column
Xcol_group_6
+ clk
+ vdd
+ vss
+ bl[24]
+ bl[25]
+ bl[26]
+ bl[27]
+ br[24]
+ br[25]
+ br[26]
+ br[27]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[6]
+ dout[6]
+ sense_en
+ column
Xcol_group_7
+ clk
+ vdd
+ vss
+ bl[28]
+ bl[29]
+ bl[30]
+ bl[31]
+ br[28]
+ br[29]
+ br[30]
+ br[31]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[7]
+ dout[7]
+ sense_en
+ column
Xcol_group_8
+ clk
+ vdd
+ vss
+ bl[32]
+ bl[33]
+ bl[34]
+ bl[35]
+ br[32]
+ br[33]
+ br[34]
+ br[35]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[8]
+ dout[8]
+ sense_en
+ column
Xcol_group_9
+ clk
+ vdd
+ vss
+ bl[36]
+ bl[37]
+ bl[38]
+ bl[39]
+ br[36]
+ br[37]
+ br[38]
+ br[39]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[9]
+ dout[9]
+ sense_en
+ column
Xcol_group_10
+ clk
+ vdd
+ vss
+ bl[40]
+ bl[41]
+ bl[42]
+ bl[43]
+ br[40]
+ br[41]
+ br[42]
+ br[43]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[10]
+ dout[10]
+ sense_en
+ column
Xcol_group_11
+ clk
+ vdd
+ vss
+ bl[44]
+ bl[45]
+ bl[46]
+ bl[47]
+ br[44]
+ br[45]
+ br[46]
+ br[47]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[11]
+ dout[11]
+ sense_en
+ column
Xcol_group_12
+ clk
+ vdd
+ vss
+ bl[48]
+ bl[49]
+ bl[50]
+ bl[51]
+ br[48]
+ br[49]
+ br[50]
+ br[51]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[12]
+ dout[12]
+ sense_en
+ column
Xcol_group_13
+ clk
+ vdd
+ vss
+ bl[52]
+ bl[53]
+ bl[54]
+ bl[55]
+ br[52]
+ br[53]
+ br[54]
+ br[55]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[13]
+ dout[13]
+ sense_en
+ column
Xcol_group_14
+ clk
+ vdd
+ vss
+ bl[56]
+ bl[57]
+ bl[58]
+ bl[59]
+ br[56]
+ br[57]
+ br[58]
+ br[59]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[14]
+ dout[14]
+ sense_en
+ column
Xcol_group_15
+ clk
+ vdd
+ vss
+ bl[60]
+ bl[61]
+ bl[62]
+ bl[63]
+ br[60]
+ br[61]
+ br[62]
+ br[63]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[15]
+ dout[15]
+ sense_en
+ column
Xcol_group_16
+ clk
+ vdd
+ vss
+ bl[64]
+ bl[65]
+ bl[66]
+ bl[67]
+ br[64]
+ br[65]
+ br[66]
+ br[67]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[16]
+ dout[16]
+ sense_en
+ column
Xcol_group_17
+ clk
+ vdd
+ vss
+ bl[68]
+ bl[69]
+ bl[70]
+ bl[71]
+ br[68]
+ br[69]
+ br[70]
+ br[71]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[17]
+ dout[17]
+ sense_en
+ column
Xcol_group_18
+ clk
+ vdd
+ vss
+ bl[72]
+ bl[73]
+ bl[74]
+ bl[75]
+ br[72]
+ br[73]
+ br[74]
+ br[75]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[18]
+ dout[18]
+ sense_en
+ column
Xcol_group_19
+ clk
+ vdd
+ vss
+ bl[76]
+ bl[77]
+ bl[78]
+ bl[79]
+ br[76]
+ br[77]
+ br[78]
+ br[79]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[19]
+ dout[19]
+ sense_en
+ column
Xcol_group_20
+ clk
+ vdd
+ vss
+ bl[80]
+ bl[81]
+ bl[82]
+ bl[83]
+ br[80]
+ br[81]
+ br[82]
+ br[83]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[20]
+ dout[20]
+ sense_en
+ column
Xcol_group_21
+ clk
+ vdd
+ vss
+ bl[84]
+ bl[85]
+ bl[86]
+ bl[87]
+ br[84]
+ br[85]
+ br[86]
+ br[87]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[21]
+ dout[21]
+ sense_en
+ column
Xcol_group_22
+ clk
+ vdd
+ vss
+ bl[88]
+ bl[89]
+ bl[90]
+ bl[91]
+ br[88]
+ br[89]
+ br[90]
+ br[91]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[22]
+ dout[22]
+ sense_en
+ column
Xcol_group_23
+ clk
+ vdd
+ vss
+ bl[92]
+ bl[93]
+ bl[94]
+ bl[95]
+ br[92]
+ br[93]
+ br[94]
+ br[95]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[23]
+ dout[23]
+ sense_en
+ column
Xcol_group_24
+ clk
+ vdd
+ vss
+ bl[96]
+ bl[97]
+ bl[98]
+ bl[99]
+ br[96]
+ br[97]
+ br[98]
+ br[99]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[24]
+ dout[24]
+ sense_en
+ column
Xcol_group_25
+ clk
+ vdd
+ vss
+ bl[100]
+ bl[101]
+ bl[102]
+ bl[103]
+ br[100]
+ br[101]
+ br[102]
+ br[103]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[25]
+ dout[25]
+ sense_en
+ column
Xcol_group_26
+ clk
+ vdd
+ vss
+ bl[104]
+ bl[105]
+ bl[106]
+ bl[107]
+ br[104]
+ br[105]
+ br[106]
+ br[107]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[26]
+ dout[26]
+ sense_en
+ column
Xcol_group_27
+ clk
+ vdd
+ vss
+ bl[108]
+ bl[109]
+ bl[110]
+ bl[111]
+ br[108]
+ br[109]
+ br[110]
+ br[111]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[27]
+ dout[27]
+ sense_en
+ column
Xcol_group_28
+ clk
+ vdd
+ vss
+ bl[112]
+ bl[113]
+ bl[114]
+ bl[115]
+ br[112]
+ br[113]
+ br[114]
+ br[115]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[28]
+ dout[28]
+ sense_en
+ column
Xcol_group_29
+ clk
+ vdd
+ vss
+ bl[116]
+ bl[117]
+ bl[118]
+ bl[119]
+ br[116]
+ br[117]
+ br[118]
+ br[119]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[29]
+ dout[29]
+ sense_en
+ column
Xcol_group_30
+ clk
+ vdd
+ vss
+ bl[120]
+ bl[121]
+ bl[122]
+ bl[123]
+ br[120]
+ br[121]
+ br[122]
+ br[123]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[30]
+ dout[30]
+ sense_en
+ column
Xcol_group_31
+ clk
+ vdd
+ vss
+ bl[124]
+ bl[125]
+ bl[126]
+ bl[127]
+ br[124]
+ br[125]
+ br[126]
+ br[127]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask_in
+ din[31]
+ dout[31]
+ sense_en
+ column
Xdummy_precharge
+ vdd
+ dummy_bl
+ dummy_br
+ pc_b
+ precharge
Xdummy_precharge_noconn
+ vdd
+ dummy_bl_noconn
+ dummy_br_noconn
+ pc_b
+ precharge
.ends col_peripherals

.subckt precharge
+ vdd
+ bl
+ br
+ en_b

Xbl_pull_up
+ bl
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xbr_pull_up
+ br
+ en_b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xequalizer
+ bl
+ en_b
+ br
+ vdd
+ mos_w1200_l150_m1_nf1_id1
.ends precharge

.subckt and2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2

.subckt decoder_stage
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode[16]
+ decode[17]
+ decode[18]
+ decode[19]
+ decode[20]
+ decode[21]
+ decode[22]
+ decode[23]
+ decode[24]
+ decode[25]
+ decode[26]
+ decode[27]
+ decode[28]
+ decode[29]
+ decode[30]
+ decode[31]
+ decode[32]
+ decode[33]
+ decode[34]
+ decode[35]
+ decode[36]
+ decode[37]
+ decode[38]
+ decode[39]
+ decode[40]
+ decode[41]
+ decode[42]
+ decode[43]
+ decode[44]
+ decode[45]
+ decode[46]
+ decode[47]
+ decode[48]
+ decode[49]
+ decode[50]
+ decode[51]
+ decode[52]
+ decode[53]
+ decode[54]
+ decode[55]
+ decode[56]
+ decode[57]
+ decode[58]
+ decode[59]
+ decode[60]
+ decode[61]
+ decode[62]
+ decode[63]
+ decode[64]
+ decode[65]
+ decode[66]
+ decode[67]
+ decode[68]
+ decode[69]
+ decode[70]
+ decode[71]
+ decode[72]
+ decode[73]
+ decode[74]
+ decode[75]
+ decode[76]
+ decode[77]
+ decode[78]
+ decode[79]
+ decode[80]
+ decode[81]
+ decode[82]
+ decode[83]
+ decode[84]
+ decode[85]
+ decode[86]
+ decode[87]
+ decode[88]
+ decode[89]
+ decode[90]
+ decode[91]
+ decode[92]
+ decode[93]
+ decode[94]
+ decode[95]
+ decode[96]
+ decode[97]
+ decode[98]
+ decode[99]
+ decode[100]
+ decode[101]
+ decode[102]
+ decode[103]
+ decode[104]
+ decode[105]
+ decode[106]
+ decode[107]
+ decode[108]
+ decode[109]
+ decode[110]
+ decode[111]
+ decode[112]
+ decode[113]
+ decode[114]
+ decode[115]
+ decode[116]
+ decode[117]
+ decode[118]
+ decode[119]
+ decode[120]
+ decode[121]
+ decode[122]
+ decode[123]
+ decode[124]
+ decode[125]
+ decode[126]
+ decode[127]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ decode_b[16]
+ decode_b[17]
+ decode_b[18]
+ decode_b[19]
+ decode_b[20]
+ decode_b[21]
+ decode_b[22]
+ decode_b[23]
+ decode_b[24]
+ decode_b[25]
+ decode_b[26]
+ decode_b[27]
+ decode_b[28]
+ decode_b[29]
+ decode_b[30]
+ decode_b[31]
+ decode_b[32]
+ decode_b[33]
+ decode_b[34]
+ decode_b[35]
+ decode_b[36]
+ decode_b[37]
+ decode_b[38]
+ decode_b[39]
+ decode_b[40]
+ decode_b[41]
+ decode_b[42]
+ decode_b[43]
+ decode_b[44]
+ decode_b[45]
+ decode_b[46]
+ decode_b[47]
+ decode_b[48]
+ decode_b[49]
+ decode_b[50]
+ decode_b[51]
+ decode_b[52]
+ decode_b[53]
+ decode_b[54]
+ decode_b[55]
+ decode_b[56]
+ decode_b[57]
+ decode_b[58]
+ decode_b[59]
+ decode_b[60]
+ decode_b[61]
+ decode_b[62]
+ decode_b[63]
+ decode_b[64]
+ decode_b[65]
+ decode_b[66]
+ decode_b[67]
+ decode_b[68]
+ decode_b[69]
+ decode_b[70]
+ decode_b[71]
+ decode_b[72]
+ decode_b[73]
+ decode_b[74]
+ decode_b[75]
+ decode_b[76]
+ decode_b[77]
+ decode_b[78]
+ decode_b[79]
+ decode_b[80]
+ decode_b[81]
+ decode_b[82]
+ decode_b[83]
+ decode_b[84]
+ decode_b[85]
+ decode_b[86]
+ decode_b[87]
+ decode_b[88]
+ decode_b[89]
+ decode_b[90]
+ decode_b[91]
+ decode_b[92]
+ decode_b[93]
+ decode_b[94]
+ decode_b[95]
+ decode_b[96]
+ decode_b[97]
+ decode_b[98]
+ decode_b[99]
+ decode_b[100]
+ decode_b[101]
+ decode_b[102]
+ decode_b[103]
+ decode_b[104]
+ decode_b[105]
+ decode_b[106]
+ decode_b[107]
+ decode_b[108]
+ decode_b[109]
+ decode_b[110]
+ decode_b[111]
+ decode_b[112]
+ decode_b[113]
+ decode_b[114]
+ decode_b[115]
+ decode_b[116]
+ decode_b[117]
+ decode_b[118]
+ decode_b[119]
+ decode_b[120]
+ decode_b[121]
+ decode_b[122]
+ decode_b[123]
+ decode_b[124]
+ decode_b[125]
+ decode_b[126]
+ decode_b[127]
+ a[0]
+ a[1]
+ a[2]
+ a[3]
+ a[4]
+ a[5]
+ a[6]
+ a[7]
+ b[0]
+ b[1]
+ b[2]
+ b[3]
+ b[4]
+ b[5]
+ b[6]
+ b[7]
+ b[8]
+ b[9]
+ b[10]
+ b[11]
+ b[12]
+ b[13]
+ b[14]
+ b[15]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_2
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_2
X0_2
+ vdd
+ a[0]
+ b[2]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_2
X0_3
+ vdd
+ a[0]
+ b[3]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_2
X0_4
+ vdd
+ a[0]
+ b[4]
+ decode[4]
+ decode_b[4]
+ vss
+ and2_2
X0_5
+ vdd
+ a[0]
+ b[5]
+ decode[5]
+ decode_b[5]
+ vss
+ and2_2
X0_6
+ vdd
+ a[0]
+ b[6]
+ decode[6]
+ decode_b[6]
+ vss
+ and2_2
X0_7
+ vdd
+ a[0]
+ b[7]
+ decode[7]
+ decode_b[7]
+ vss
+ and2_2
X0_8
+ vdd
+ a[0]
+ b[8]
+ decode[8]
+ decode_b[8]
+ vss
+ and2_2
X0_9
+ vdd
+ a[0]
+ b[9]
+ decode[9]
+ decode_b[9]
+ vss
+ and2_2
X0_10
+ vdd
+ a[0]
+ b[10]
+ decode[10]
+ decode_b[10]
+ vss
+ and2_2
X0_11
+ vdd
+ a[0]
+ b[11]
+ decode[11]
+ decode_b[11]
+ vss
+ and2_2
X0_12
+ vdd
+ a[0]
+ b[12]
+ decode[12]
+ decode_b[12]
+ vss
+ and2_2
X0_13
+ vdd
+ a[0]
+ b[13]
+ decode[13]
+ decode_b[13]
+ vss
+ and2_2
X0_14
+ vdd
+ a[0]
+ b[14]
+ decode[14]
+ decode_b[14]
+ vss
+ and2_2
X0_15
+ vdd
+ a[0]
+ b[15]
+ decode[15]
+ decode_b[15]
+ vss
+ and2_2
X0_16
+ vdd
+ a[1]
+ b[0]
+ decode[16]
+ decode_b[16]
+ vss
+ and2_2
X0_17
+ vdd
+ a[1]
+ b[1]
+ decode[17]
+ decode_b[17]
+ vss
+ and2_2
X0_18
+ vdd
+ a[1]
+ b[2]
+ decode[18]
+ decode_b[18]
+ vss
+ and2_2
X0_19
+ vdd
+ a[1]
+ b[3]
+ decode[19]
+ decode_b[19]
+ vss
+ and2_2
X0_20
+ vdd
+ a[1]
+ b[4]
+ decode[20]
+ decode_b[20]
+ vss
+ and2_2
X0_21
+ vdd
+ a[1]
+ b[5]
+ decode[21]
+ decode_b[21]
+ vss
+ and2_2
X0_22
+ vdd
+ a[1]
+ b[6]
+ decode[22]
+ decode_b[22]
+ vss
+ and2_2
X0_23
+ vdd
+ a[1]
+ b[7]
+ decode[23]
+ decode_b[23]
+ vss
+ and2_2
X0_24
+ vdd
+ a[1]
+ b[8]
+ decode[24]
+ decode_b[24]
+ vss
+ and2_2
X0_25
+ vdd
+ a[1]
+ b[9]
+ decode[25]
+ decode_b[25]
+ vss
+ and2_2
X0_26
+ vdd
+ a[1]
+ b[10]
+ decode[26]
+ decode_b[26]
+ vss
+ and2_2
X0_27
+ vdd
+ a[1]
+ b[11]
+ decode[27]
+ decode_b[27]
+ vss
+ and2_2
X0_28
+ vdd
+ a[1]
+ b[12]
+ decode[28]
+ decode_b[28]
+ vss
+ and2_2
X0_29
+ vdd
+ a[1]
+ b[13]
+ decode[29]
+ decode_b[29]
+ vss
+ and2_2
X0_30
+ vdd
+ a[1]
+ b[14]
+ decode[30]
+ decode_b[30]
+ vss
+ and2_2
X0_31
+ vdd
+ a[1]
+ b[15]
+ decode[31]
+ decode_b[31]
+ vss
+ and2_2
X0_32
+ vdd
+ a[2]
+ b[0]
+ decode[32]
+ decode_b[32]
+ vss
+ and2_2
X0_33
+ vdd
+ a[2]
+ b[1]
+ decode[33]
+ decode_b[33]
+ vss
+ and2_2
X0_34
+ vdd
+ a[2]
+ b[2]
+ decode[34]
+ decode_b[34]
+ vss
+ and2_2
X0_35
+ vdd
+ a[2]
+ b[3]
+ decode[35]
+ decode_b[35]
+ vss
+ and2_2
X0_36
+ vdd
+ a[2]
+ b[4]
+ decode[36]
+ decode_b[36]
+ vss
+ and2_2
X0_37
+ vdd
+ a[2]
+ b[5]
+ decode[37]
+ decode_b[37]
+ vss
+ and2_2
X0_38
+ vdd
+ a[2]
+ b[6]
+ decode[38]
+ decode_b[38]
+ vss
+ and2_2
X0_39
+ vdd
+ a[2]
+ b[7]
+ decode[39]
+ decode_b[39]
+ vss
+ and2_2
X0_40
+ vdd
+ a[2]
+ b[8]
+ decode[40]
+ decode_b[40]
+ vss
+ and2_2
X0_41
+ vdd
+ a[2]
+ b[9]
+ decode[41]
+ decode_b[41]
+ vss
+ and2_2
X0_42
+ vdd
+ a[2]
+ b[10]
+ decode[42]
+ decode_b[42]
+ vss
+ and2_2
X0_43
+ vdd
+ a[2]
+ b[11]
+ decode[43]
+ decode_b[43]
+ vss
+ and2_2
X0_44
+ vdd
+ a[2]
+ b[12]
+ decode[44]
+ decode_b[44]
+ vss
+ and2_2
X0_45
+ vdd
+ a[2]
+ b[13]
+ decode[45]
+ decode_b[45]
+ vss
+ and2_2
X0_46
+ vdd
+ a[2]
+ b[14]
+ decode[46]
+ decode_b[46]
+ vss
+ and2_2
X0_47
+ vdd
+ a[2]
+ b[15]
+ decode[47]
+ decode_b[47]
+ vss
+ and2_2
X0_48
+ vdd
+ a[3]
+ b[0]
+ decode[48]
+ decode_b[48]
+ vss
+ and2_2
X0_49
+ vdd
+ a[3]
+ b[1]
+ decode[49]
+ decode_b[49]
+ vss
+ and2_2
X0_50
+ vdd
+ a[3]
+ b[2]
+ decode[50]
+ decode_b[50]
+ vss
+ and2_2
X0_51
+ vdd
+ a[3]
+ b[3]
+ decode[51]
+ decode_b[51]
+ vss
+ and2_2
X0_52
+ vdd
+ a[3]
+ b[4]
+ decode[52]
+ decode_b[52]
+ vss
+ and2_2
X0_53
+ vdd
+ a[3]
+ b[5]
+ decode[53]
+ decode_b[53]
+ vss
+ and2_2
X0_54
+ vdd
+ a[3]
+ b[6]
+ decode[54]
+ decode_b[54]
+ vss
+ and2_2
X0_55
+ vdd
+ a[3]
+ b[7]
+ decode[55]
+ decode_b[55]
+ vss
+ and2_2
X0_56
+ vdd
+ a[3]
+ b[8]
+ decode[56]
+ decode_b[56]
+ vss
+ and2_2
X0_57
+ vdd
+ a[3]
+ b[9]
+ decode[57]
+ decode_b[57]
+ vss
+ and2_2
X0_58
+ vdd
+ a[3]
+ b[10]
+ decode[58]
+ decode_b[58]
+ vss
+ and2_2
X0_59
+ vdd
+ a[3]
+ b[11]
+ decode[59]
+ decode_b[59]
+ vss
+ and2_2
X0_60
+ vdd
+ a[3]
+ b[12]
+ decode[60]
+ decode_b[60]
+ vss
+ and2_2
X0_61
+ vdd
+ a[3]
+ b[13]
+ decode[61]
+ decode_b[61]
+ vss
+ and2_2
X0_62
+ vdd
+ a[3]
+ b[14]
+ decode[62]
+ decode_b[62]
+ vss
+ and2_2
X0_63
+ vdd
+ a[3]
+ b[15]
+ decode[63]
+ decode_b[63]
+ vss
+ and2_2
X0_64
+ vdd
+ a[4]
+ b[0]
+ decode[64]
+ decode_b[64]
+ vss
+ and2_2
X0_65
+ vdd
+ a[4]
+ b[1]
+ decode[65]
+ decode_b[65]
+ vss
+ and2_2
X0_66
+ vdd
+ a[4]
+ b[2]
+ decode[66]
+ decode_b[66]
+ vss
+ and2_2
X0_67
+ vdd
+ a[4]
+ b[3]
+ decode[67]
+ decode_b[67]
+ vss
+ and2_2
X0_68
+ vdd
+ a[4]
+ b[4]
+ decode[68]
+ decode_b[68]
+ vss
+ and2_2
X0_69
+ vdd
+ a[4]
+ b[5]
+ decode[69]
+ decode_b[69]
+ vss
+ and2_2
X0_70
+ vdd
+ a[4]
+ b[6]
+ decode[70]
+ decode_b[70]
+ vss
+ and2_2
X0_71
+ vdd
+ a[4]
+ b[7]
+ decode[71]
+ decode_b[71]
+ vss
+ and2_2
X0_72
+ vdd
+ a[4]
+ b[8]
+ decode[72]
+ decode_b[72]
+ vss
+ and2_2
X0_73
+ vdd
+ a[4]
+ b[9]
+ decode[73]
+ decode_b[73]
+ vss
+ and2_2
X0_74
+ vdd
+ a[4]
+ b[10]
+ decode[74]
+ decode_b[74]
+ vss
+ and2_2
X0_75
+ vdd
+ a[4]
+ b[11]
+ decode[75]
+ decode_b[75]
+ vss
+ and2_2
X0_76
+ vdd
+ a[4]
+ b[12]
+ decode[76]
+ decode_b[76]
+ vss
+ and2_2
X0_77
+ vdd
+ a[4]
+ b[13]
+ decode[77]
+ decode_b[77]
+ vss
+ and2_2
X0_78
+ vdd
+ a[4]
+ b[14]
+ decode[78]
+ decode_b[78]
+ vss
+ and2_2
X0_79
+ vdd
+ a[4]
+ b[15]
+ decode[79]
+ decode_b[79]
+ vss
+ and2_2
X0_80
+ vdd
+ a[5]
+ b[0]
+ decode[80]
+ decode_b[80]
+ vss
+ and2_2
X0_81
+ vdd
+ a[5]
+ b[1]
+ decode[81]
+ decode_b[81]
+ vss
+ and2_2
X0_82
+ vdd
+ a[5]
+ b[2]
+ decode[82]
+ decode_b[82]
+ vss
+ and2_2
X0_83
+ vdd
+ a[5]
+ b[3]
+ decode[83]
+ decode_b[83]
+ vss
+ and2_2
X0_84
+ vdd
+ a[5]
+ b[4]
+ decode[84]
+ decode_b[84]
+ vss
+ and2_2
X0_85
+ vdd
+ a[5]
+ b[5]
+ decode[85]
+ decode_b[85]
+ vss
+ and2_2
X0_86
+ vdd
+ a[5]
+ b[6]
+ decode[86]
+ decode_b[86]
+ vss
+ and2_2
X0_87
+ vdd
+ a[5]
+ b[7]
+ decode[87]
+ decode_b[87]
+ vss
+ and2_2
X0_88
+ vdd
+ a[5]
+ b[8]
+ decode[88]
+ decode_b[88]
+ vss
+ and2_2
X0_89
+ vdd
+ a[5]
+ b[9]
+ decode[89]
+ decode_b[89]
+ vss
+ and2_2
X0_90
+ vdd
+ a[5]
+ b[10]
+ decode[90]
+ decode_b[90]
+ vss
+ and2_2
X0_91
+ vdd
+ a[5]
+ b[11]
+ decode[91]
+ decode_b[91]
+ vss
+ and2_2
X0_92
+ vdd
+ a[5]
+ b[12]
+ decode[92]
+ decode_b[92]
+ vss
+ and2_2
X0_93
+ vdd
+ a[5]
+ b[13]
+ decode[93]
+ decode_b[93]
+ vss
+ and2_2
X0_94
+ vdd
+ a[5]
+ b[14]
+ decode[94]
+ decode_b[94]
+ vss
+ and2_2
X0_95
+ vdd
+ a[5]
+ b[15]
+ decode[95]
+ decode_b[95]
+ vss
+ and2_2
X0_96
+ vdd
+ a[6]
+ b[0]
+ decode[96]
+ decode_b[96]
+ vss
+ and2_2
X0_97
+ vdd
+ a[6]
+ b[1]
+ decode[97]
+ decode_b[97]
+ vss
+ and2_2
X0_98
+ vdd
+ a[6]
+ b[2]
+ decode[98]
+ decode_b[98]
+ vss
+ and2_2
X0_99
+ vdd
+ a[6]
+ b[3]
+ decode[99]
+ decode_b[99]
+ vss
+ and2_2
X0_100
+ vdd
+ a[6]
+ b[4]
+ decode[100]
+ decode_b[100]
+ vss
+ and2_2
X0_101
+ vdd
+ a[6]
+ b[5]
+ decode[101]
+ decode_b[101]
+ vss
+ and2_2
X0_102
+ vdd
+ a[6]
+ b[6]
+ decode[102]
+ decode_b[102]
+ vss
+ and2_2
X0_103
+ vdd
+ a[6]
+ b[7]
+ decode[103]
+ decode_b[103]
+ vss
+ and2_2
X0_104
+ vdd
+ a[6]
+ b[8]
+ decode[104]
+ decode_b[104]
+ vss
+ and2_2
X0_105
+ vdd
+ a[6]
+ b[9]
+ decode[105]
+ decode_b[105]
+ vss
+ and2_2
X0_106
+ vdd
+ a[6]
+ b[10]
+ decode[106]
+ decode_b[106]
+ vss
+ and2_2
X0_107
+ vdd
+ a[6]
+ b[11]
+ decode[107]
+ decode_b[107]
+ vss
+ and2_2
X0_108
+ vdd
+ a[6]
+ b[12]
+ decode[108]
+ decode_b[108]
+ vss
+ and2_2
X0_109
+ vdd
+ a[6]
+ b[13]
+ decode[109]
+ decode_b[109]
+ vss
+ and2_2
X0_110
+ vdd
+ a[6]
+ b[14]
+ decode[110]
+ decode_b[110]
+ vss
+ and2_2
X0_111
+ vdd
+ a[6]
+ b[15]
+ decode[111]
+ decode_b[111]
+ vss
+ and2_2
X0_112
+ vdd
+ a[7]
+ b[0]
+ decode[112]
+ decode_b[112]
+ vss
+ and2_2
X0_113
+ vdd
+ a[7]
+ b[1]
+ decode[113]
+ decode_b[113]
+ vss
+ and2_2
X0_114
+ vdd
+ a[7]
+ b[2]
+ decode[114]
+ decode_b[114]
+ vss
+ and2_2
X0_115
+ vdd
+ a[7]
+ b[3]
+ decode[115]
+ decode_b[115]
+ vss
+ and2_2
X0_116
+ vdd
+ a[7]
+ b[4]
+ decode[116]
+ decode_b[116]
+ vss
+ and2_2
X0_117
+ vdd
+ a[7]
+ b[5]
+ decode[117]
+ decode_b[117]
+ vss
+ and2_2
X0_118
+ vdd
+ a[7]
+ b[6]
+ decode[118]
+ decode_b[118]
+ vss
+ and2_2
X0_119
+ vdd
+ a[7]
+ b[7]
+ decode[119]
+ decode_b[119]
+ vss
+ and2_2
X0_120
+ vdd
+ a[7]
+ b[8]
+ decode[120]
+ decode_b[120]
+ vss
+ and2_2
X0_121
+ vdd
+ a[7]
+ b[9]
+ decode[121]
+ decode_b[121]
+ vss
+ and2_2
X0_122
+ vdd
+ a[7]
+ b[10]
+ decode[122]
+ decode_b[122]
+ vss
+ and2_2
X0_123
+ vdd
+ a[7]
+ b[11]
+ decode[123]
+ decode_b[123]
+ vss
+ and2_2
X0_124
+ vdd
+ a[7]
+ b[12]
+ decode[124]
+ decode_b[124]
+ vss
+ and2_2
X0_125
+ vdd
+ a[7]
+ b[13]
+ decode[125]
+ decode_b[125]
+ vss
+ and2_2
X0_126
+ vdd
+ a[7]
+ b[14]
+ decode[126]
+ decode_b[126]
+ vss
+ and2_2
X0_127
+ vdd
+ a[7]
+ b[15]
+ decode[127]
+ decode_b[127]
+ vss
+ and2_2
.ends decoder_stage

.subckt decoder_stage_1
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ a[0]
+ a[1]
+ b[0]
+ b[1]
+ c[0]
+ c[1]

X0
+ vdd
+ a[0]
+ b[0]
+ c[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and3
X0_1
+ vdd
+ a[0]
+ b[0]
+ c[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and3
X0_2
+ vdd
+ a[0]
+ b[1]
+ c[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and3
X0_3
+ vdd
+ a[0]
+ b[1]
+ c[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and3
X0_4
+ vdd
+ a[1]
+ b[0]
+ c[0]
+ decode[4]
+ decode_b[4]
+ vss
+ and3
X0_5
+ vdd
+ a[1]
+ b[0]
+ c[1]
+ decode[5]
+ decode_b[5]
+ vss
+ and3
X0_6
+ vdd
+ a[1]
+ b[1]
+ c[0]
+ decode[6]
+ decode_b[6]
+ vss
+ and3
X0_7
+ vdd
+ a[1]
+ b[1]
+ c[1]
+ decode[7]
+ decode_b[7]
+ vss
+ and3
.ends decoder_stage_1

.subckt decoder_stage_2
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode[4]
+ decode[5]
+ decode[6]
+ decode[7]
+ decode[8]
+ decode[9]
+ decode[10]
+ decode[11]
+ decode[12]
+ decode[13]
+ decode[14]
+ decode[15]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ decode_b[4]
+ decode_b[5]
+ decode_b[6]
+ decode_b[7]
+ decode_b[8]
+ decode_b[9]
+ decode_b[10]
+ decode_b[11]
+ decode_b[12]
+ decode_b[13]
+ decode_b[14]
+ decode_b[15]
+ a[0]
+ a[1]
+ a[2]
+ a[3]
+ b[0]
+ b[1]
+ b[2]
+ b[3]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_3
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_3
X0_2
+ vdd
+ a[0]
+ b[2]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_3
X0_3
+ vdd
+ a[0]
+ b[3]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_3
X0_4
+ vdd
+ a[1]
+ b[0]
+ decode[4]
+ decode_b[4]
+ vss
+ and2_3
X0_5
+ vdd
+ a[1]
+ b[1]
+ decode[5]
+ decode_b[5]
+ vss
+ and2_3
X0_6
+ vdd
+ a[1]
+ b[2]
+ decode[6]
+ decode_b[6]
+ vss
+ and2_3
X0_7
+ vdd
+ a[1]
+ b[3]
+ decode[7]
+ decode_b[7]
+ vss
+ and2_3
X0_8
+ vdd
+ a[2]
+ b[0]
+ decode[8]
+ decode_b[8]
+ vss
+ and2_3
X0_9
+ vdd
+ a[2]
+ b[1]
+ decode[9]
+ decode_b[9]
+ vss
+ and2_3
X0_10
+ vdd
+ a[2]
+ b[2]
+ decode[10]
+ decode_b[10]
+ vss
+ and2_3
X0_11
+ vdd
+ a[2]
+ b[3]
+ decode[11]
+ decode_b[11]
+ vss
+ and2_3
X0_12
+ vdd
+ a[3]
+ b[0]
+ decode[12]
+ decode_b[12]
+ vss
+ and2_3
X0_13
+ vdd
+ a[3]
+ b[1]
+ decode[13]
+ decode_b[13]
+ vss
+ and2_3
X0_14
+ vdd
+ a[3]
+ b[2]
+ decode[14]
+ decode_b[14]
+ vss
+ and2_3
X0_15
+ vdd
+ a[3]
+ b[3]
+ decode[15]
+ decode_b[15]
+ vss
+ and2_3
.ends decoder_stage_2

.subckt decoder_stage_3
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ a[0]
+ a[1]
+ b[0]
+ b[1]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_3
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_3
X0_2
+ vdd
+ a[1]
+ b[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_3
X0_3
+ vdd
+ a[1]
+ b[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_3
.ends decoder_stage_3

.subckt decoder_stage_4
+ vdd
+ vss
+ decode[0]
+ decode[1]
+ decode[2]
+ decode[3]
+ decode_b[0]
+ decode_b[1]
+ decode_b[2]
+ decode_b[3]
+ a[0]
+ a[1]
+ b[0]
+ b[1]

X0
+ vdd
+ a[0]
+ b[0]
+ decode[0]
+ decode_b[0]
+ vss
+ and2_4
X0_1
+ vdd
+ a[0]
+ b[1]
+ decode[1]
+ decode_b[1]
+ vss
+ and2_4
X0_2
+ vdd
+ a[1]
+ b[0]
+ decode[2]
+ decode_b[2]
+ vss
+ and2_4
X0_3
+ vdd
+ a[1]
+ b[1]
+ decode[3]
+ decode_b[3]
+ vss
+ and2_4
.ends decoder_stage_4

.subckt and2_1
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_1

.subckt sky130_fd_sc_hd__inv_2_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__inv_2
.ends sky130_fd_sc_hd__inv_2_wrapper

.subckt edge_detector
+ din
+ dout
+ vdd
+ vss

Xdelay_chain
+ din
+ delayed
+ vdd
+ vss
+ inv_chain_9
Xand
+ din
+ delayed
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__and2_4_wrapper
.ends edge_detector

.subckt inv_chain_4
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_4

.subckt inv_chain_48
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ x[15]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv16
+ x[15]
+ vss
+ vss
+ vdd
+ vdd
+ x[16]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv17
+ x[16]
+ vss
+ vss
+ vdd
+ vdd
+ x[17]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv18
+ x[17]
+ vss
+ vss
+ vdd
+ vdd
+ x[18]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv19
+ x[18]
+ vss
+ vss
+ vdd
+ vdd
+ x[19]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv20
+ x[19]
+ vss
+ vss
+ vdd
+ vdd
+ x[20]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv21
+ x[20]
+ vss
+ vss
+ vdd
+ vdd
+ x[21]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv22
+ x[21]
+ vss
+ vss
+ vdd
+ vdd
+ x[22]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv23
+ x[22]
+ vss
+ vss
+ vdd
+ vdd
+ x[23]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv24
+ x[23]
+ vss
+ vss
+ vdd
+ vdd
+ x[24]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv25
+ x[24]
+ vss
+ vss
+ vdd
+ vdd
+ x[25]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv26
+ x[25]
+ vss
+ vss
+ vdd
+ vdd
+ x[26]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv27
+ x[26]
+ vss
+ vss
+ vdd
+ vdd
+ x[27]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv28
+ x[27]
+ vss
+ vss
+ vdd
+ vdd
+ x[28]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv29
+ x[28]
+ vss
+ vss
+ vdd
+ vdd
+ x[29]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv30
+ x[29]
+ vss
+ vss
+ vdd
+ vdd
+ x[30]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv31
+ x[30]
+ vss
+ vss
+ vdd
+ vdd
+ x[31]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv32
+ x[31]
+ vss
+ vss
+ vdd
+ vdd
+ x[32]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv33
+ x[32]
+ vss
+ vss
+ vdd
+ vdd
+ x[33]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv34
+ x[33]
+ vss
+ vss
+ vdd
+ vdd
+ x[34]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv35
+ x[34]
+ vss
+ vss
+ vdd
+ vdd
+ x[35]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv36
+ x[35]
+ vss
+ vss
+ vdd
+ vdd
+ x[36]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv37
+ x[36]
+ vss
+ vss
+ vdd
+ vdd
+ x[37]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv38
+ x[37]
+ vss
+ vss
+ vdd
+ vdd
+ x[38]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv39
+ x[38]
+ vss
+ vss
+ vdd
+ vdd
+ x[39]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv40
+ x[39]
+ vss
+ vss
+ vdd
+ vdd
+ x[40]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv41
+ x[40]
+ vss
+ vss
+ vdd
+ vdd
+ x[41]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv42
+ x[41]
+ vss
+ vss
+ vdd
+ vdd
+ x[42]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv43
+ x[42]
+ vss
+ vss
+ vdd
+ vdd
+ x[43]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv44
+ x[43]
+ vss
+ vss
+ vdd
+ vdd
+ x[44]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv45
+ x[44]
+ vss
+ vss
+ vdd
+ vdd
+ x[45]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv46
+ x[45]
+ vss
+ vss
+ vdd
+ vdd
+ x[46]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv47
+ x[46]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_48

.subckt sky130_fd_sc_hd__and2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_2
.ends sky130_fd_sc_hd__and2_2_wrapper

.subckt sr_latch
+ s
+ r
+ q
+ qb
+ vdd
+ vss

Xnor_set
+ s
+ q
+ vss
+ vss
+ vdd
+ vdd
+ qb
+ sky130_fd_sc_hd__nor2_2_wrapper
Xnor_reset
+ r
+ qb
+ vss
+ vss
+ vdd
+ vdd
+ q
+ sky130_fd_sc_hd__nor2_2_wrapper
.ends sr_latch

.subckt sky130_fd_sc_hd__mux2_2_wrapper
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A0
+ A1
+ S
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__mux2_2
.ends sky130_fd_sc_hd__mux2_2_wrapper

.subckt inv_chain_8
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_8

.subckt inv_chain_16
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ x[8]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv9
+ x[8]
+ vss
+ vss
+ vdd
+ vdd
+ x[9]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv10
+ x[9]
+ vss
+ vss
+ vdd
+ vdd
+ x[10]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv11
+ x[10]
+ vss
+ vss
+ vdd
+ vdd
+ x[11]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv12
+ x[11]
+ vss
+ vss
+ vdd
+ vdd
+ x[12]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv13
+ x[12]
+ vss
+ vss
+ vdd
+ vdd
+ x[13]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv14
+ x[13]
+ vss
+ vss
+ vdd
+ vdd
+ x[14]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv15
+ x[14]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_16

.subckt sky130_fd_sc_hd__bufbuf_16_wrapper
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__bufbuf_16
.ends sky130_fd_sc_hd__bufbuf_16_wrapper

.subckt mos_w420_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=0.420 l=0.150 nf=1 mult=1
.ends mos_w420_l150_m1_nf1_id0

.subckt openram_dff_wrapper
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N

X0
+ VDD
+ GND
+ CLK
+ D
+ Q
+ Q_N
+ openram_dff
.ends openram_dff_wrapper

.subckt sram_sp_cell_wrapper
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB

X0
+ BL
+ BR
+ VDD
+ VSS
+ WL
+ VNB
+ VPB
+ sram_sp_cell
.ends sram_sp_cell_wrapper

.subckt sram_sp_colend_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_colend
.ends sram_sp_colend_wrapper

.subckt sram_sp_hstrap_wrapper
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB

X0
+ BR
+ VDD
+ VSS
+ BL
+ VNB
+ VPB
+ sram_sp_hstrap
.ends sram_sp_hstrap_wrapper

.subckt sram_sp_cell_replica_wrapper
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL

X0
+ BL
+ BR
+ VSS
+ VDD
+ VPB
+ VNB
+ WL
+ sram_sp_cell_replica
.ends sram_sp_cell_replica_wrapper

.subckt dff_array_1
+ vdd
+ vss
+ clk
+ d
+ q
+ qn

Xdff_0
+ vdd
+ vss
+ clk
+ d
+ q
+ qn
+ openram_dff_wrapper
.ends dff_array_1

.subckt column
+ clk
+ vdd
+ vss
+ bl[0]
+ bl[1]
+ bl[2]
+ bl[3]
+ br[0]
+ br[1]
+ br[2]
+ br[3]
+ pc_b
+ sel_b[0]
+ sel_b[1]
+ sel_b[2]
+ sel_b[3]
+ we[0]
+ we[1]
+ we[2]
+ we[3]
+ wmask
+ din
+ dout
+ sense_en

Xprecharge_0
+ vdd
+ bl[0]
+ br[0]
+ pc_b
+ precharge
Xread_mux_0
+ sel_b[0]
+ bl[0]
+ br[0]
+ bl_out
+ br_out
+ vdd
+ read_mux
Xwrite_mux_0
+ we[0]
+ wmask
+ q
+ q_b
+ bl[0]
+ br[0]
+ vss
+ write_mux
Xprecharge_1
+ vdd
+ bl[1]
+ br[1]
+ pc_b
+ precharge
Xread_mux_1
+ sel_b[1]
+ bl[1]
+ br[1]
+ bl_out
+ br_out
+ vdd
+ read_mux_1
Xwrite_mux_1
+ we[1]
+ wmask
+ q
+ q_b
+ bl[1]
+ br[1]
+ vss
+ write_mux_1
Xprecharge_2
+ vdd
+ bl[2]
+ br[2]
+ pc_b
+ precharge
Xread_mux_2
+ sel_b[2]
+ bl[2]
+ br[2]
+ bl_out
+ br_out
+ vdd
+ read_mux_2
Xwrite_mux_2
+ we[2]
+ wmask
+ q
+ q_b
+ bl[2]
+ br[2]
+ vss
+ write_mux_2
Xprecharge_3
+ vdd
+ bl[3]
+ br[3]
+ pc_b
+ precharge
Xread_mux_3
+ sel_b[3]
+ bl[3]
+ br[3]
+ bl_out
+ br_out
+ vdd
+ read_mux_3
Xwrite_mux_3
+ we[3]
+ wmask
+ q
+ q_b
+ bl[3]
+ br[3]
+ vss
+ write_mux_3
Xsense_amp
+ sense_en
+ br_out
+ bl_out
+ sa_outn
+ sa_outp
+ vdd
+ vss
+ sramgen_sp_sense_amp_wrapper
Xbuf
+ vdd
+ vss
+ sa_outp
+ sa_outn
+ dout
+ diff_buf_outn
+ diff_buf
Xdff
+ vdd
+ vss
+ clk
+ din
+ q
+ q_b
+ openram_dff_wrapper
.ends column

.subckt mos_w2000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=2.000 l=0.150 nf=1 mult=1
.ends mos_w2000_l150_m1_nf1_id1

.subckt mos_w1200_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id1

.subckt nand2
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w8000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w8000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
.ends nand2

.subckt inv
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w13600_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1200_l150_m1_nf1_id0
.ends inv

.subckt and2_2
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv
.ends and2_2

.subckt and3
+ vdd
+ a
+ b
+ c
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ c
+ yb
+ nand3
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_2
.ends and3

.subckt and2_3
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_2
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_2
.ends and2_3

.subckt and2_4
+ vdd
+ a
+ b
+ y
+ yb
+ vss

X0
+ vdd
+ vss
+ a
+ b
+ yb
+ nand2_1
X0_1
+ vdd
+ vss
+ yb
+ y
+ inv_1
.ends and2_4

.subckt nand2_1
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
.ends nand2_1

.subckt inv_1
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w4000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w2000_l150_m1_nf1_id0
.ends inv_1

.subckt inv_chain_9
+ din
+ dout
+ vdd
+ vss

Xinv0
+ din
+ vss
+ vss
+ vdd
+ vdd
+ x[0]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv1
+ x[0]
+ vss
+ vss
+ vdd
+ vdd
+ x[1]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv2
+ x[1]
+ vss
+ vss
+ vdd
+ vdd
+ x[2]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv3
+ x[2]
+ vss
+ vss
+ vdd
+ vdd
+ x[3]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv4
+ x[3]
+ vss
+ vss
+ vdd
+ vdd
+ x[4]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv5
+ x[4]
+ vss
+ vss
+ vdd
+ vdd
+ x[5]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv6
+ x[5]
+ vss
+ vss
+ vdd
+ vdd
+ x[6]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv7
+ x[6]
+ vss
+ vss
+ vdd
+ vdd
+ x[7]
+ sky130_fd_sc_hd__inv_2_wrapper
Xinv8
+ x[7]
+ vss
+ vss
+ vdd
+ vdd
+ dout
+ sky130_fd_sc_hd__inv_2_wrapper
.ends inv_chain_9

.subckt sky130_fd_sc_hd__and2_4_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ X
+ sky130_fd_sc_hd__and2_4
.ends sky130_fd_sc_hd__and2_4_wrapper

.subckt sky130_fd_sc_hd__nor2_2_wrapper
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y

X0
+ A
+ B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Y
+ sky130_fd_sc_hd__nor2_2
.ends sky130_fd_sc_hd__nor2_2_wrapper

.subckt read_mux
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux

.subckt write_mux
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux

.subckt read_mux_1
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_1

.subckt write_mux_1
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_1

.subckt read_mux_2
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_2

.subckt write_mux_2
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_2

.subckt read_mux_3
+ sel_b
+ bl
+ br
+ bl_out
+ br_out
+ vdd

XMBL
+ bl_out
+ sel_b
+ bl
+ vdd
+ mos_w3000_l150_m1_nf1_id1
XMBR
+ br_out
+ sel_b
+ br
+ vdd
+ mos_w3000_l150_m1_nf1_id1
.ends read_mux_3

.subckt write_mux_3
+ we
+ wmask
+ data
+ data_b
+ bl
+ br
+ vss

XMMUXBR
+ br
+ data
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMMUXBL
+ bl
+ data_b
+ x
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMWMASK
+ x
+ wmask
+ y
+ vss
+ mos_w2400_l150_m1_nf1_id0
XMPD
+ y
+ we
+ vss
+ vss
+ mos_w2400_l150_m1_nf1_id0
.ends write_mux_3

.subckt sramgen_sp_sense_amp_wrapper
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS

X0
+ clk
+ inn
+ inp
+ outn
+ outp
+ VDD
+ VSS
+ sramgen_sp_sense_amp
.ends sramgen_sp_sense_amp_wrapper

.subckt diff_buf
+ vdd
+ vss
+ din1
+ din2
+ dout1
+ dout2

Xbuf_1
+ vdd
+ vss
+ din1
+ dout1
+ buf
Xbuf_2
+ vdd
+ vss
+ din2
+ dout2
+ buf
.ends diff_buf

.subckt mos_w8000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=8.000 l=0.150 nf=1 mult=1
.ends mos_w8000_l150_m1_nf1_id0

.subckt mos_w13600_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=13.600 l=0.150 nf=1 mult=1
.ends mos_w13600_l150_m1_nf1_id1

.subckt mos_w1200_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=1.200 l=0.150 nf=1 mult=1
.ends mos_w1200_l150_m1_nf1_id0

.subckt nand3
+ vdd
+ vss
+ a
+ b
+ c
+ y

Xn1
+ x1
+ a
+ vss
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn2
+ x2
+ b
+ x1
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn3
+ y
+ c
+ x2
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
Xp3
+ y
+ c
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
.ends nand3

.subckt inv_2
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w6800_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w600_l150_m1_nf1_id0
.ends inv_2

.subckt nand2_2
+ vdd
+ vss
+ a
+ b
+ y

Xn1
+ x
+ a
+ vss
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xn2
+ y
+ b
+ x
+ vss
+ mos_w4000_l150_m1_nf1_id0
Xp1
+ y
+ a
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
Xp2
+ y
+ b
+ vdd
+ vdd
+ mos_w1000_l150_m1_nf1_id1
.ends nand2_2

.subckt mos_w4000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=4.000 l=0.150 nf=1 mult=1
.ends mos_w4000_l150_m1_nf1_id0

.subckt mos_w4000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=4.000 l=0.150 nf=1 mult=1
.ends mos_w4000_l150_m1_nf1_id1

.subckt mos_w2000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=2.000 l=0.150 nf=1 mult=1
.ends mos_w2000_l150_m1_nf1_id0

.subckt mos_w3000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=3.000 l=0.150 nf=1 mult=1
.ends mos_w3000_l150_m1_nf1_id1

.subckt mos_w2400_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=2.400 l=0.150 nf=1 mult=1
.ends mos_w2400_l150_m1_nf1_id0

.subckt buf
+ vdd
+ vss
+ din
+ dout

Xinv_1
+ vdd
+ vss
+ din
+ x
+ inv_3
Xinv_2
+ vdd
+ vss
+ x
+ dout
+ inv_3
.ends buf

.subckt mos_w1000_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.000 l=0.150 nf=1 mult=1
.ends mos_w1000_l150_m1_nf1_id1

.subckt mos_w6800_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=6.800 l=0.150 nf=1 mult=1
.ends mos_w6800_l150_m1_nf1_id1

.subckt mos_w600_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=0.600 l=0.150 nf=1 mult=1
.ends mos_w600_l150_m1_nf1_id0

.subckt inv_3
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w2000_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1200_l150_m1_nf1_id0
.ends inv_3

.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_4.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/openram_dff.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/sram_sp_cell.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/sram_sp_colend.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/sramgen_sp_sense_amp.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/nor2/sky130_fd_sc_hd__nor2_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/inv/sky130_fd_sc_hd__inv_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/and2/sky130_fd_sc_hd__and2_2.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/mux2/sky130_fd_sc_hd__mux2_2.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/sram_sp_cell_replica.spice"
.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/bufbuf/sky130_fd_sc_hd__bufbuf_16.spice"
.include "/bwrcq/C/rahulkumar/personal/sram223/tech/sky130/spice/sram_sp_hstrap.spice"
